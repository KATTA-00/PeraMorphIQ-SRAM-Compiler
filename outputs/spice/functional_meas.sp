.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_0ck70 FIND v(dout0_0) AT=40.025n

.meas tran vdout0_1ck70 FIND v(dout0_1) AT=40.025n

.meas tran vdout0_2ck70 FIND v(dout0_2) AT=40.025n

.meas tran vdout0_3ck70 FIND v(dout0_3) AT=40.025n

.meas tran vdout0_4ck70 FIND v(dout0_4) AT=40.025n

.meas tran vdout0_5ck70 FIND v(dout0_5) AT=40.025n

.meas tran vdout0_6ck70 FIND v(dout0_6) AT=40.025n

.meas tran vdout0_7ck70 FIND v(dout0_7) AT=40.025n

.meas tran vdout0_8ck70 FIND v(dout0_8) AT=40.025n

.meas tran vdout0_9ck70 FIND v(dout0_9) AT=40.025n

.meas tran vdout0_10ck70 FIND v(dout0_10) AT=40.025n

.meas tran vdout0_11ck70 FIND v(dout0_11) AT=40.025n

.meas tran vdout0_12ck70 FIND v(dout0_12) AT=40.025n

.meas tran vdout0_13ck70 FIND v(dout0_13) AT=40.025n

.meas tran vdout0_14ck70 FIND v(dout0_14) AT=40.025n

.meas tran vdout0_15ck70 FIND v(dout0_15) AT=40.025n

.meas tran vdout0_16ck70 FIND v(dout0_16) AT=40.025n

.meas tran vdout0_17ck70 FIND v(dout0_17) AT=40.025n

.meas tran vdout0_18ck70 FIND v(dout0_18) AT=40.025n

.meas tran vdout0_19ck70 FIND v(dout0_19) AT=40.025n

.meas tran vdout0_20ck70 FIND v(dout0_20) AT=40.025n

.meas tran vdout0_21ck70 FIND v(dout0_21) AT=40.025n

.meas tran vdout0_22ck70 FIND v(dout0_22) AT=40.025n

.meas tran vdout0_23ck70 FIND v(dout0_23) AT=40.025n

.meas tran vdout0_24ck70 FIND v(dout0_24) AT=40.025n

.meas tran vdout0_25ck70 FIND v(dout0_25) AT=40.025n

.meas tran vdout0_26ck70 FIND v(dout0_26) AT=40.025n

.meas tran vdout0_27ck70 FIND v(dout0_27) AT=40.025n

.meas tran vdout0_28ck70 FIND v(dout0_28) AT=40.025n

.meas tran vdout0_29ck70 FIND v(dout0_29) AT=40.025n

.meas tran vdout0_30ck70 FIND v(dout0_30) AT=40.025n

.meas tran vdout0_31ck70 FIND v(dout0_31) AT=40.025n

.meas tran vdout0_32ck70 FIND v(dout0_32) AT=40.025n

.meas tran vdout0_33ck70 FIND v(dout0_33) AT=40.025n

.meas tran vdout0_34ck70 FIND v(dout0_34) AT=40.025n

.meas tran vdout0_35ck70 FIND v(dout0_35) AT=40.025n

.meas tran vdout0_36ck70 FIND v(dout0_36) AT=40.025n

.meas tran vdout0_37ck70 FIND v(dout0_37) AT=40.025n

.meas tran vdout0_38ck70 FIND v(dout0_38) AT=40.025n

.meas tran vdout0_39ck70 FIND v(dout0_39) AT=40.025n

.meas tran vdout0_40ck70 FIND v(dout0_40) AT=40.025n

.meas tran vdout0_41ck70 FIND v(dout0_41) AT=40.025n

.meas tran vdout0_42ck70 FIND v(dout0_42) AT=40.025n

.meas tran vdout0_43ck70 FIND v(dout0_43) AT=40.025n

.meas tran vdout0_44ck70 FIND v(dout0_44) AT=40.025n

.meas tran vdout0_45ck70 FIND v(dout0_45) AT=40.025n

.meas tran vdout0_46ck70 FIND v(dout0_46) AT=40.025n

.meas tran vdout0_47ck70 FIND v(dout0_47) AT=40.025n

.meas tran vdout0_48ck70 FIND v(dout0_48) AT=40.025n

.meas tran vdout0_49ck70 FIND v(dout0_49) AT=40.025n

.meas tran vdout0_50ck70 FIND v(dout0_50) AT=40.025n

.meas tran vdout0_51ck70 FIND v(dout0_51) AT=40.025n

.meas tran vdout0_52ck70 FIND v(dout0_52) AT=40.025n

.meas tran vdout0_53ck70 FIND v(dout0_53) AT=40.025n

.meas tran vdout0_54ck70 FIND v(dout0_54) AT=40.025n

.meas tran vdout0_55ck70 FIND v(dout0_55) AT=40.025n

.meas tran vdout0_56ck70 FIND v(dout0_56) AT=40.025n

.meas tran vdout0_57ck70 FIND v(dout0_57) AT=40.025n

.meas tran vdout0_58ck70 FIND v(dout0_58) AT=40.025n

.meas tran vdout0_59ck70 FIND v(dout0_59) AT=40.025n

.meas tran vdout0_60ck70 FIND v(dout0_60) AT=40.025n

.meas tran vdout0_61ck70 FIND v(dout0_61) AT=40.025n

.meas tran vdout0_62ck70 FIND v(dout0_62) AT=40.025n

.meas tran vdout0_63ck70 FIND v(dout0_63) AT=40.025n

.meas tran vdout0_64ck70 FIND v(dout0_64) AT=40.025n

.meas tran vdout0_65ck70 FIND v(dout0_65) AT=40.025n

.meas tran vdout0_66ck70 FIND v(dout0_66) AT=40.025n

.meas tran vdout0_67ck70 FIND v(dout0_67) AT=40.025n

.meas tran vdout0_68ck70 FIND v(dout0_68) AT=40.025n

.meas tran vdout0_69ck70 FIND v(dout0_69) AT=40.025n

.meas tran vdout0_70ck70 FIND v(dout0_70) AT=40.025n

.meas tran vdout0_71ck70 FIND v(dout0_71) AT=40.025n

.meas tran vdout0_72ck70 FIND v(dout0_72) AT=40.025n

.meas tran vdout0_73ck70 FIND v(dout0_73) AT=40.025n

.meas tran vdout0_74ck70 FIND v(dout0_74) AT=40.025n

.meas tran vdout0_75ck70 FIND v(dout0_75) AT=40.025n

.meas tran vdout0_76ck70 FIND v(dout0_76) AT=40.025n

.meas tran vdout0_77ck70 FIND v(dout0_77) AT=40.025n

.meas tran vdout0_78ck70 FIND v(dout0_78) AT=40.025n

.meas tran vdout0_79ck70 FIND v(dout0_79) AT=40.025n

.meas tran vdout0_80ck70 FIND v(dout0_80) AT=40.025n

.meas tran vdout0_81ck70 FIND v(dout0_81) AT=40.025n

.meas tran vdout0_82ck70 FIND v(dout0_82) AT=40.025n

.meas tran vdout0_83ck70 FIND v(dout0_83) AT=40.025n

.meas tran vdout0_84ck70 FIND v(dout0_84) AT=40.025n

.meas tran vdout0_85ck70 FIND v(dout0_85) AT=40.025n

.meas tran vdout0_86ck70 FIND v(dout0_86) AT=40.025n

.meas tran vdout0_87ck70 FIND v(dout0_87) AT=40.025n

.meas tran vdout0_88ck70 FIND v(dout0_88) AT=40.025n

.meas tran vdout0_89ck70 FIND v(dout0_89) AT=40.025n

.meas tran vdout0_90ck70 FIND v(dout0_90) AT=40.025n

.meas tran vdout0_91ck70 FIND v(dout0_91) AT=40.025n

.meas tran vdout0_92ck70 FIND v(dout0_92) AT=40.025n

.meas tran vdout0_93ck70 FIND v(dout0_93) AT=40.025n

.meas tran vdout0_94ck70 FIND v(dout0_94) AT=40.025n

.meas tran vdout0_95ck70 FIND v(dout0_95) AT=40.025n

.meas tran vdout0_96ck70 FIND v(dout0_96) AT=40.025n

.meas tran vdout0_97ck70 FIND v(dout0_97) AT=40.025n

.meas tran vdout0_98ck70 FIND v(dout0_98) AT=40.025n

.meas tran vdout0_99ck70 FIND v(dout0_99) AT=40.025n

.meas tran vdout0_100ck70 FIND v(dout0_100) AT=40.025n

.meas tran vdout0_101ck70 FIND v(dout0_101) AT=40.025n

.meas tran vdout0_102ck70 FIND v(dout0_102) AT=40.025n

.meas tran vdout0_103ck70 FIND v(dout0_103) AT=40.025n

.meas tran vdout0_104ck70 FIND v(dout0_104) AT=40.025n

.meas tran vdout0_105ck70 FIND v(dout0_105) AT=40.025n

.meas tran vdout0_106ck70 FIND v(dout0_106) AT=40.025n

.meas tran vdout0_107ck70 FIND v(dout0_107) AT=40.025n

.meas tran vdout0_108ck70 FIND v(dout0_108) AT=40.025n

.meas tran vdout0_109ck70 FIND v(dout0_109) AT=40.025n

.meas tran vdout0_110ck70 FIND v(dout0_110) AT=40.025n

.meas tran vdout0_111ck70 FIND v(dout0_111) AT=40.025n

.meas tran vdout0_112ck70 FIND v(dout0_112) AT=40.025n

.meas tran vdout0_113ck70 FIND v(dout0_113) AT=40.025n

.meas tran vdout0_114ck70 FIND v(dout0_114) AT=40.025n

.meas tran vdout0_115ck70 FIND v(dout0_115) AT=40.025n

.meas tran vdout0_116ck70 FIND v(dout0_116) AT=40.025n

.meas tran vdout0_117ck70 FIND v(dout0_117) AT=40.025n

.meas tran vdout0_118ck70 FIND v(dout0_118) AT=40.025n

.meas tran vdout0_119ck70 FIND v(dout0_119) AT=40.025n

.meas tran vdout0_120ck70 FIND v(dout0_120) AT=40.025n

.meas tran vdout0_121ck70 FIND v(dout0_121) AT=40.025n

.meas tran vdout0_122ck70 FIND v(dout0_122) AT=40.025n

.meas tran vdout0_123ck70 FIND v(dout0_123) AT=40.025n

.meas tran vdout0_124ck70 FIND v(dout0_124) AT=40.025n

.meas tran vdout0_125ck70 FIND v(dout0_125) AT=40.025n

.meas tran vdout0_126ck70 FIND v(dout0_126) AT=40.025n

.meas tran vdout0_127ck70 FIND v(dout0_127) AT=40.025n

.meas tran vdout0_0ck110 FIND v(dout0_0) AT=60.025n

.meas tran vdout0_1ck110 FIND v(dout0_1) AT=60.025n

.meas tran vdout0_2ck110 FIND v(dout0_2) AT=60.025n

.meas tran vdout0_3ck110 FIND v(dout0_3) AT=60.025n

.meas tran vdout0_4ck110 FIND v(dout0_4) AT=60.025n

.meas tran vdout0_5ck110 FIND v(dout0_5) AT=60.025n

.meas tran vdout0_6ck110 FIND v(dout0_6) AT=60.025n

.meas tran vdout0_7ck110 FIND v(dout0_7) AT=60.025n

.meas tran vdout0_8ck110 FIND v(dout0_8) AT=60.025n

.meas tran vdout0_9ck110 FIND v(dout0_9) AT=60.025n

.meas tran vdout0_10ck110 FIND v(dout0_10) AT=60.025n

.meas tran vdout0_11ck110 FIND v(dout0_11) AT=60.025n

.meas tran vdout0_12ck110 FIND v(dout0_12) AT=60.025n

.meas tran vdout0_13ck110 FIND v(dout0_13) AT=60.025n

.meas tran vdout0_14ck110 FIND v(dout0_14) AT=60.025n

.meas tran vdout0_15ck110 FIND v(dout0_15) AT=60.025n

.meas tran vdout0_16ck110 FIND v(dout0_16) AT=60.025n

.meas tran vdout0_17ck110 FIND v(dout0_17) AT=60.025n

.meas tran vdout0_18ck110 FIND v(dout0_18) AT=60.025n

.meas tran vdout0_19ck110 FIND v(dout0_19) AT=60.025n

.meas tran vdout0_20ck110 FIND v(dout0_20) AT=60.025n

.meas tran vdout0_21ck110 FIND v(dout0_21) AT=60.025n

.meas tran vdout0_22ck110 FIND v(dout0_22) AT=60.025n

.meas tran vdout0_23ck110 FIND v(dout0_23) AT=60.025n

.meas tran vdout0_24ck110 FIND v(dout0_24) AT=60.025n

.meas tran vdout0_25ck110 FIND v(dout0_25) AT=60.025n

.meas tran vdout0_26ck110 FIND v(dout0_26) AT=60.025n

.meas tran vdout0_27ck110 FIND v(dout0_27) AT=60.025n

.meas tran vdout0_28ck110 FIND v(dout0_28) AT=60.025n

.meas tran vdout0_29ck110 FIND v(dout0_29) AT=60.025n

.meas tran vdout0_30ck110 FIND v(dout0_30) AT=60.025n

.meas tran vdout0_31ck110 FIND v(dout0_31) AT=60.025n

.meas tran vdout0_32ck110 FIND v(dout0_32) AT=60.025n

.meas tran vdout0_33ck110 FIND v(dout0_33) AT=60.025n

.meas tran vdout0_34ck110 FIND v(dout0_34) AT=60.025n

.meas tran vdout0_35ck110 FIND v(dout0_35) AT=60.025n

.meas tran vdout0_36ck110 FIND v(dout0_36) AT=60.025n

.meas tran vdout0_37ck110 FIND v(dout0_37) AT=60.025n

.meas tran vdout0_38ck110 FIND v(dout0_38) AT=60.025n

.meas tran vdout0_39ck110 FIND v(dout0_39) AT=60.025n

.meas tran vdout0_40ck110 FIND v(dout0_40) AT=60.025n

.meas tran vdout0_41ck110 FIND v(dout0_41) AT=60.025n

.meas tran vdout0_42ck110 FIND v(dout0_42) AT=60.025n

.meas tran vdout0_43ck110 FIND v(dout0_43) AT=60.025n

.meas tran vdout0_44ck110 FIND v(dout0_44) AT=60.025n

.meas tran vdout0_45ck110 FIND v(dout0_45) AT=60.025n

.meas tran vdout0_46ck110 FIND v(dout0_46) AT=60.025n

.meas tran vdout0_47ck110 FIND v(dout0_47) AT=60.025n

.meas tran vdout0_48ck110 FIND v(dout0_48) AT=60.025n

.meas tran vdout0_49ck110 FIND v(dout0_49) AT=60.025n

.meas tran vdout0_50ck110 FIND v(dout0_50) AT=60.025n

.meas tran vdout0_51ck110 FIND v(dout0_51) AT=60.025n

.meas tran vdout0_52ck110 FIND v(dout0_52) AT=60.025n

.meas tran vdout0_53ck110 FIND v(dout0_53) AT=60.025n

.meas tran vdout0_54ck110 FIND v(dout0_54) AT=60.025n

.meas tran vdout0_55ck110 FIND v(dout0_55) AT=60.025n

.meas tran vdout0_56ck110 FIND v(dout0_56) AT=60.025n

.meas tran vdout0_57ck110 FIND v(dout0_57) AT=60.025n

.meas tran vdout0_58ck110 FIND v(dout0_58) AT=60.025n

.meas tran vdout0_59ck110 FIND v(dout0_59) AT=60.025n

.meas tran vdout0_60ck110 FIND v(dout0_60) AT=60.025n

.meas tran vdout0_61ck110 FIND v(dout0_61) AT=60.025n

.meas tran vdout0_62ck110 FIND v(dout0_62) AT=60.025n

.meas tran vdout0_63ck110 FIND v(dout0_63) AT=60.025n

.meas tran vdout0_64ck110 FIND v(dout0_64) AT=60.025n

.meas tran vdout0_65ck110 FIND v(dout0_65) AT=60.025n

.meas tran vdout0_66ck110 FIND v(dout0_66) AT=60.025n

.meas tran vdout0_67ck110 FIND v(dout0_67) AT=60.025n

.meas tran vdout0_68ck110 FIND v(dout0_68) AT=60.025n

.meas tran vdout0_69ck110 FIND v(dout0_69) AT=60.025n

.meas tran vdout0_70ck110 FIND v(dout0_70) AT=60.025n

.meas tran vdout0_71ck110 FIND v(dout0_71) AT=60.025n

.meas tran vdout0_72ck110 FIND v(dout0_72) AT=60.025n

.meas tran vdout0_73ck110 FIND v(dout0_73) AT=60.025n

.meas tran vdout0_74ck110 FIND v(dout0_74) AT=60.025n

.meas tran vdout0_75ck110 FIND v(dout0_75) AT=60.025n

.meas tran vdout0_76ck110 FIND v(dout0_76) AT=60.025n

.meas tran vdout0_77ck110 FIND v(dout0_77) AT=60.025n

.meas tran vdout0_78ck110 FIND v(dout0_78) AT=60.025n

.meas tran vdout0_79ck110 FIND v(dout0_79) AT=60.025n

.meas tran vdout0_80ck110 FIND v(dout0_80) AT=60.025n

.meas tran vdout0_81ck110 FIND v(dout0_81) AT=60.025n

.meas tran vdout0_82ck110 FIND v(dout0_82) AT=60.025n

.meas tran vdout0_83ck110 FIND v(dout0_83) AT=60.025n

.meas tran vdout0_84ck110 FIND v(dout0_84) AT=60.025n

.meas tran vdout0_85ck110 FIND v(dout0_85) AT=60.025n

.meas tran vdout0_86ck110 FIND v(dout0_86) AT=60.025n

.meas tran vdout0_87ck110 FIND v(dout0_87) AT=60.025n

.meas tran vdout0_88ck110 FIND v(dout0_88) AT=60.025n

.meas tran vdout0_89ck110 FIND v(dout0_89) AT=60.025n

.meas tran vdout0_90ck110 FIND v(dout0_90) AT=60.025n

.meas tran vdout0_91ck110 FIND v(dout0_91) AT=60.025n

.meas tran vdout0_92ck110 FIND v(dout0_92) AT=60.025n

.meas tran vdout0_93ck110 FIND v(dout0_93) AT=60.025n

.meas tran vdout0_94ck110 FIND v(dout0_94) AT=60.025n

.meas tran vdout0_95ck110 FIND v(dout0_95) AT=60.025n

.meas tran vdout0_96ck110 FIND v(dout0_96) AT=60.025n

.meas tran vdout0_97ck110 FIND v(dout0_97) AT=60.025n

.meas tran vdout0_98ck110 FIND v(dout0_98) AT=60.025n

.meas tran vdout0_99ck110 FIND v(dout0_99) AT=60.025n

.meas tran vdout0_100ck110 FIND v(dout0_100) AT=60.025n

.meas tran vdout0_101ck110 FIND v(dout0_101) AT=60.025n

.meas tran vdout0_102ck110 FIND v(dout0_102) AT=60.025n

.meas tran vdout0_103ck110 FIND v(dout0_103) AT=60.025n

.meas tran vdout0_104ck110 FIND v(dout0_104) AT=60.025n

.meas tran vdout0_105ck110 FIND v(dout0_105) AT=60.025n

.meas tran vdout0_106ck110 FIND v(dout0_106) AT=60.025n

.meas tran vdout0_107ck110 FIND v(dout0_107) AT=60.025n

.meas tran vdout0_108ck110 FIND v(dout0_108) AT=60.025n

.meas tran vdout0_109ck110 FIND v(dout0_109) AT=60.025n

.meas tran vdout0_110ck110 FIND v(dout0_110) AT=60.025n

.meas tran vdout0_111ck110 FIND v(dout0_111) AT=60.025n

.meas tran vdout0_112ck110 FIND v(dout0_112) AT=60.025n

.meas tran vdout0_113ck110 FIND v(dout0_113) AT=60.025n

.meas tran vdout0_114ck110 FIND v(dout0_114) AT=60.025n

.meas tran vdout0_115ck110 FIND v(dout0_115) AT=60.025n

.meas tran vdout0_116ck110 FIND v(dout0_116) AT=60.025n

.meas tran vdout0_117ck110 FIND v(dout0_117) AT=60.025n

.meas tran vdout0_118ck110 FIND v(dout0_118) AT=60.025n

.meas tran vdout0_119ck110 FIND v(dout0_119) AT=60.025n

.meas tran vdout0_120ck110 FIND v(dout0_120) AT=60.025n

.meas tran vdout0_121ck110 FIND v(dout0_121) AT=60.025n

.meas tran vdout0_122ck110 FIND v(dout0_122) AT=60.025n

.meas tran vdout0_123ck110 FIND v(dout0_123) AT=60.025n

.meas tran vdout0_124ck110 FIND v(dout0_124) AT=60.025n

.meas tran vdout0_125ck110 FIND v(dout0_125) AT=60.025n

.meas tran vdout0_126ck110 FIND v(dout0_126) AT=60.025n

.meas tran vdout0_127ck110 FIND v(dout0_127) AT=60.025n

.meas tran vdout0_0ck130 FIND v(dout0_0) AT=70.025n

.meas tran vdout0_1ck130 FIND v(dout0_1) AT=70.025n

.meas tran vdout0_2ck130 FIND v(dout0_2) AT=70.025n

.meas tran vdout0_3ck130 FIND v(dout0_3) AT=70.025n

.meas tran vdout0_4ck130 FIND v(dout0_4) AT=70.025n

.meas tran vdout0_5ck130 FIND v(dout0_5) AT=70.025n

.meas tran vdout0_6ck130 FIND v(dout0_6) AT=70.025n

.meas tran vdout0_7ck130 FIND v(dout0_7) AT=70.025n

.meas tran vdout0_8ck130 FIND v(dout0_8) AT=70.025n

.meas tran vdout0_9ck130 FIND v(dout0_9) AT=70.025n

.meas tran vdout0_10ck130 FIND v(dout0_10) AT=70.025n

.meas tran vdout0_11ck130 FIND v(dout0_11) AT=70.025n

.meas tran vdout0_12ck130 FIND v(dout0_12) AT=70.025n

.meas tran vdout0_13ck130 FIND v(dout0_13) AT=70.025n

.meas tran vdout0_14ck130 FIND v(dout0_14) AT=70.025n

.meas tran vdout0_15ck130 FIND v(dout0_15) AT=70.025n

.meas tran vdout0_16ck130 FIND v(dout0_16) AT=70.025n

.meas tran vdout0_17ck130 FIND v(dout0_17) AT=70.025n

.meas tran vdout0_18ck130 FIND v(dout0_18) AT=70.025n

.meas tran vdout0_19ck130 FIND v(dout0_19) AT=70.025n

.meas tran vdout0_20ck130 FIND v(dout0_20) AT=70.025n

.meas tran vdout0_21ck130 FIND v(dout0_21) AT=70.025n

.meas tran vdout0_22ck130 FIND v(dout0_22) AT=70.025n

.meas tran vdout0_23ck130 FIND v(dout0_23) AT=70.025n

.meas tran vdout0_24ck130 FIND v(dout0_24) AT=70.025n

.meas tran vdout0_25ck130 FIND v(dout0_25) AT=70.025n

.meas tran vdout0_26ck130 FIND v(dout0_26) AT=70.025n

.meas tran vdout0_27ck130 FIND v(dout0_27) AT=70.025n

.meas tran vdout0_28ck130 FIND v(dout0_28) AT=70.025n

.meas tran vdout0_29ck130 FIND v(dout0_29) AT=70.025n

.meas tran vdout0_30ck130 FIND v(dout0_30) AT=70.025n

.meas tran vdout0_31ck130 FIND v(dout0_31) AT=70.025n

.meas tran vdout0_32ck130 FIND v(dout0_32) AT=70.025n

.meas tran vdout0_33ck130 FIND v(dout0_33) AT=70.025n

.meas tran vdout0_34ck130 FIND v(dout0_34) AT=70.025n

.meas tran vdout0_35ck130 FIND v(dout0_35) AT=70.025n

.meas tran vdout0_36ck130 FIND v(dout0_36) AT=70.025n

.meas tran vdout0_37ck130 FIND v(dout0_37) AT=70.025n

.meas tran vdout0_38ck130 FIND v(dout0_38) AT=70.025n

.meas tran vdout0_39ck130 FIND v(dout0_39) AT=70.025n

.meas tran vdout0_40ck130 FIND v(dout0_40) AT=70.025n

.meas tran vdout0_41ck130 FIND v(dout0_41) AT=70.025n

.meas tran vdout0_42ck130 FIND v(dout0_42) AT=70.025n

.meas tran vdout0_43ck130 FIND v(dout0_43) AT=70.025n

.meas tran vdout0_44ck130 FIND v(dout0_44) AT=70.025n

.meas tran vdout0_45ck130 FIND v(dout0_45) AT=70.025n

.meas tran vdout0_46ck130 FIND v(dout0_46) AT=70.025n

.meas tran vdout0_47ck130 FIND v(dout0_47) AT=70.025n

.meas tran vdout0_48ck130 FIND v(dout0_48) AT=70.025n

.meas tran vdout0_49ck130 FIND v(dout0_49) AT=70.025n

.meas tran vdout0_50ck130 FIND v(dout0_50) AT=70.025n

.meas tran vdout0_51ck130 FIND v(dout0_51) AT=70.025n

.meas tran vdout0_52ck130 FIND v(dout0_52) AT=70.025n

.meas tran vdout0_53ck130 FIND v(dout0_53) AT=70.025n

.meas tran vdout0_54ck130 FIND v(dout0_54) AT=70.025n

.meas tran vdout0_55ck130 FIND v(dout0_55) AT=70.025n

.meas tran vdout0_56ck130 FIND v(dout0_56) AT=70.025n

.meas tran vdout0_57ck130 FIND v(dout0_57) AT=70.025n

.meas tran vdout0_58ck130 FIND v(dout0_58) AT=70.025n

.meas tran vdout0_59ck130 FIND v(dout0_59) AT=70.025n

.meas tran vdout0_60ck130 FIND v(dout0_60) AT=70.025n

.meas tran vdout0_61ck130 FIND v(dout0_61) AT=70.025n

.meas tran vdout0_62ck130 FIND v(dout0_62) AT=70.025n

.meas tran vdout0_63ck130 FIND v(dout0_63) AT=70.025n

.meas tran vdout0_64ck130 FIND v(dout0_64) AT=70.025n

.meas tran vdout0_65ck130 FIND v(dout0_65) AT=70.025n

.meas tran vdout0_66ck130 FIND v(dout0_66) AT=70.025n

.meas tran vdout0_67ck130 FIND v(dout0_67) AT=70.025n

.meas tran vdout0_68ck130 FIND v(dout0_68) AT=70.025n

.meas tran vdout0_69ck130 FIND v(dout0_69) AT=70.025n

.meas tran vdout0_70ck130 FIND v(dout0_70) AT=70.025n

.meas tran vdout0_71ck130 FIND v(dout0_71) AT=70.025n

.meas tran vdout0_72ck130 FIND v(dout0_72) AT=70.025n

.meas tran vdout0_73ck130 FIND v(dout0_73) AT=70.025n

.meas tran vdout0_74ck130 FIND v(dout0_74) AT=70.025n

.meas tran vdout0_75ck130 FIND v(dout0_75) AT=70.025n

.meas tran vdout0_76ck130 FIND v(dout0_76) AT=70.025n

.meas tran vdout0_77ck130 FIND v(dout0_77) AT=70.025n

.meas tran vdout0_78ck130 FIND v(dout0_78) AT=70.025n

.meas tran vdout0_79ck130 FIND v(dout0_79) AT=70.025n

.meas tran vdout0_80ck130 FIND v(dout0_80) AT=70.025n

.meas tran vdout0_81ck130 FIND v(dout0_81) AT=70.025n

.meas tran vdout0_82ck130 FIND v(dout0_82) AT=70.025n

.meas tran vdout0_83ck130 FIND v(dout0_83) AT=70.025n

.meas tran vdout0_84ck130 FIND v(dout0_84) AT=70.025n

.meas tran vdout0_85ck130 FIND v(dout0_85) AT=70.025n

.meas tran vdout0_86ck130 FIND v(dout0_86) AT=70.025n

.meas tran vdout0_87ck130 FIND v(dout0_87) AT=70.025n

.meas tran vdout0_88ck130 FIND v(dout0_88) AT=70.025n

.meas tran vdout0_89ck130 FIND v(dout0_89) AT=70.025n

.meas tran vdout0_90ck130 FIND v(dout0_90) AT=70.025n

.meas tran vdout0_91ck130 FIND v(dout0_91) AT=70.025n

.meas tran vdout0_92ck130 FIND v(dout0_92) AT=70.025n

.meas tran vdout0_93ck130 FIND v(dout0_93) AT=70.025n

.meas tran vdout0_94ck130 FIND v(dout0_94) AT=70.025n

.meas tran vdout0_95ck130 FIND v(dout0_95) AT=70.025n

.meas tran vdout0_96ck130 FIND v(dout0_96) AT=70.025n

.meas tran vdout0_97ck130 FIND v(dout0_97) AT=70.025n

.meas tran vdout0_98ck130 FIND v(dout0_98) AT=70.025n

.meas tran vdout0_99ck130 FIND v(dout0_99) AT=70.025n

.meas tran vdout0_100ck130 FIND v(dout0_100) AT=70.025n

.meas tran vdout0_101ck130 FIND v(dout0_101) AT=70.025n

.meas tran vdout0_102ck130 FIND v(dout0_102) AT=70.025n

.meas tran vdout0_103ck130 FIND v(dout0_103) AT=70.025n

.meas tran vdout0_104ck130 FIND v(dout0_104) AT=70.025n

.meas tran vdout0_105ck130 FIND v(dout0_105) AT=70.025n

.meas tran vdout0_106ck130 FIND v(dout0_106) AT=70.025n

.meas tran vdout0_107ck130 FIND v(dout0_107) AT=70.025n

.meas tran vdout0_108ck130 FIND v(dout0_108) AT=70.025n

.meas tran vdout0_109ck130 FIND v(dout0_109) AT=70.025n

.meas tran vdout0_110ck130 FIND v(dout0_110) AT=70.025n

.meas tran vdout0_111ck130 FIND v(dout0_111) AT=70.025n

.meas tran vdout0_112ck130 FIND v(dout0_112) AT=70.025n

.meas tran vdout0_113ck130 FIND v(dout0_113) AT=70.025n

.meas tran vdout0_114ck130 FIND v(dout0_114) AT=70.025n

.meas tran vdout0_115ck130 FIND v(dout0_115) AT=70.025n

.meas tran vdout0_116ck130 FIND v(dout0_116) AT=70.025n

.meas tran vdout0_117ck130 FIND v(dout0_117) AT=70.025n

.meas tran vdout0_118ck130 FIND v(dout0_118) AT=70.025n

.meas tran vdout0_119ck130 FIND v(dout0_119) AT=70.025n

.meas tran vdout0_120ck130 FIND v(dout0_120) AT=70.025n

.meas tran vdout0_121ck130 FIND v(dout0_121) AT=70.025n

.meas tran vdout0_122ck130 FIND v(dout0_122) AT=70.025n

.meas tran vdout0_123ck130 FIND v(dout0_123) AT=70.025n

.meas tran vdout0_124ck130 FIND v(dout0_124) AT=70.025n

.meas tran vdout0_125ck130 FIND v(dout0_125) AT=70.025n

.meas tran vdout0_126ck130 FIND v(dout0_126) AT=70.025n

.meas tran vdout0_127ck130 FIND v(dout0_127) AT=70.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_0ck170 FIND v(dout0_0) AT=90.025n

.meas tran vdout0_1ck170 FIND v(dout0_1) AT=90.025n

.meas tran vdout0_2ck170 FIND v(dout0_2) AT=90.025n

.meas tran vdout0_3ck170 FIND v(dout0_3) AT=90.025n

.meas tran vdout0_4ck170 FIND v(dout0_4) AT=90.025n

.meas tran vdout0_5ck170 FIND v(dout0_5) AT=90.025n

.meas tran vdout0_6ck170 FIND v(dout0_6) AT=90.025n

.meas tran vdout0_7ck170 FIND v(dout0_7) AT=90.025n

.meas tran vdout0_8ck170 FIND v(dout0_8) AT=90.025n

.meas tran vdout0_9ck170 FIND v(dout0_9) AT=90.025n

.meas tran vdout0_10ck170 FIND v(dout0_10) AT=90.025n

.meas tran vdout0_11ck170 FIND v(dout0_11) AT=90.025n

.meas tran vdout0_12ck170 FIND v(dout0_12) AT=90.025n

.meas tran vdout0_13ck170 FIND v(dout0_13) AT=90.025n

.meas tran vdout0_14ck170 FIND v(dout0_14) AT=90.025n

.meas tran vdout0_15ck170 FIND v(dout0_15) AT=90.025n

.meas tran vdout0_16ck170 FIND v(dout0_16) AT=90.025n

.meas tran vdout0_17ck170 FIND v(dout0_17) AT=90.025n

.meas tran vdout0_18ck170 FIND v(dout0_18) AT=90.025n

.meas tran vdout0_19ck170 FIND v(dout0_19) AT=90.025n

.meas tran vdout0_20ck170 FIND v(dout0_20) AT=90.025n

.meas tran vdout0_21ck170 FIND v(dout0_21) AT=90.025n

.meas tran vdout0_22ck170 FIND v(dout0_22) AT=90.025n

.meas tran vdout0_23ck170 FIND v(dout0_23) AT=90.025n

.meas tran vdout0_24ck170 FIND v(dout0_24) AT=90.025n

.meas tran vdout0_25ck170 FIND v(dout0_25) AT=90.025n

.meas tran vdout0_26ck170 FIND v(dout0_26) AT=90.025n

.meas tran vdout0_27ck170 FIND v(dout0_27) AT=90.025n

.meas tran vdout0_28ck170 FIND v(dout0_28) AT=90.025n

.meas tran vdout0_29ck170 FIND v(dout0_29) AT=90.025n

.meas tran vdout0_30ck170 FIND v(dout0_30) AT=90.025n

.meas tran vdout0_31ck170 FIND v(dout0_31) AT=90.025n

.meas tran vdout0_32ck170 FIND v(dout0_32) AT=90.025n

.meas tran vdout0_33ck170 FIND v(dout0_33) AT=90.025n

.meas tran vdout0_34ck170 FIND v(dout0_34) AT=90.025n

.meas tran vdout0_35ck170 FIND v(dout0_35) AT=90.025n

.meas tran vdout0_36ck170 FIND v(dout0_36) AT=90.025n

.meas tran vdout0_37ck170 FIND v(dout0_37) AT=90.025n

.meas tran vdout0_38ck170 FIND v(dout0_38) AT=90.025n

.meas tran vdout0_39ck170 FIND v(dout0_39) AT=90.025n

.meas tran vdout0_40ck170 FIND v(dout0_40) AT=90.025n

.meas tran vdout0_41ck170 FIND v(dout0_41) AT=90.025n

.meas tran vdout0_42ck170 FIND v(dout0_42) AT=90.025n

.meas tran vdout0_43ck170 FIND v(dout0_43) AT=90.025n

.meas tran vdout0_44ck170 FIND v(dout0_44) AT=90.025n

.meas tran vdout0_45ck170 FIND v(dout0_45) AT=90.025n

.meas tran vdout0_46ck170 FIND v(dout0_46) AT=90.025n

.meas tran vdout0_47ck170 FIND v(dout0_47) AT=90.025n

.meas tran vdout0_48ck170 FIND v(dout0_48) AT=90.025n

.meas tran vdout0_49ck170 FIND v(dout0_49) AT=90.025n

.meas tran vdout0_50ck170 FIND v(dout0_50) AT=90.025n

.meas tran vdout0_51ck170 FIND v(dout0_51) AT=90.025n

.meas tran vdout0_52ck170 FIND v(dout0_52) AT=90.025n

.meas tran vdout0_53ck170 FIND v(dout0_53) AT=90.025n

.meas tran vdout0_54ck170 FIND v(dout0_54) AT=90.025n

.meas tran vdout0_55ck170 FIND v(dout0_55) AT=90.025n

.meas tran vdout0_56ck170 FIND v(dout0_56) AT=90.025n

.meas tran vdout0_57ck170 FIND v(dout0_57) AT=90.025n

.meas tran vdout0_58ck170 FIND v(dout0_58) AT=90.025n

.meas tran vdout0_59ck170 FIND v(dout0_59) AT=90.025n

.meas tran vdout0_60ck170 FIND v(dout0_60) AT=90.025n

.meas tran vdout0_61ck170 FIND v(dout0_61) AT=90.025n

.meas tran vdout0_62ck170 FIND v(dout0_62) AT=90.025n

.meas tran vdout0_63ck170 FIND v(dout0_63) AT=90.025n

.meas tran vdout0_64ck170 FIND v(dout0_64) AT=90.025n

.meas tran vdout0_65ck170 FIND v(dout0_65) AT=90.025n

.meas tran vdout0_66ck170 FIND v(dout0_66) AT=90.025n

.meas tran vdout0_67ck170 FIND v(dout0_67) AT=90.025n

.meas tran vdout0_68ck170 FIND v(dout0_68) AT=90.025n

.meas tran vdout0_69ck170 FIND v(dout0_69) AT=90.025n

.meas tran vdout0_70ck170 FIND v(dout0_70) AT=90.025n

.meas tran vdout0_71ck170 FIND v(dout0_71) AT=90.025n

.meas tran vdout0_72ck170 FIND v(dout0_72) AT=90.025n

.meas tran vdout0_73ck170 FIND v(dout0_73) AT=90.025n

.meas tran vdout0_74ck170 FIND v(dout0_74) AT=90.025n

.meas tran vdout0_75ck170 FIND v(dout0_75) AT=90.025n

.meas tran vdout0_76ck170 FIND v(dout0_76) AT=90.025n

.meas tran vdout0_77ck170 FIND v(dout0_77) AT=90.025n

.meas tran vdout0_78ck170 FIND v(dout0_78) AT=90.025n

.meas tran vdout0_79ck170 FIND v(dout0_79) AT=90.025n

.meas tran vdout0_80ck170 FIND v(dout0_80) AT=90.025n

.meas tran vdout0_81ck170 FIND v(dout0_81) AT=90.025n

.meas tran vdout0_82ck170 FIND v(dout0_82) AT=90.025n

.meas tran vdout0_83ck170 FIND v(dout0_83) AT=90.025n

.meas tran vdout0_84ck170 FIND v(dout0_84) AT=90.025n

.meas tran vdout0_85ck170 FIND v(dout0_85) AT=90.025n

.meas tran vdout0_86ck170 FIND v(dout0_86) AT=90.025n

.meas tran vdout0_87ck170 FIND v(dout0_87) AT=90.025n

.meas tran vdout0_88ck170 FIND v(dout0_88) AT=90.025n

.meas tran vdout0_89ck170 FIND v(dout0_89) AT=90.025n

.meas tran vdout0_90ck170 FIND v(dout0_90) AT=90.025n

.meas tran vdout0_91ck170 FIND v(dout0_91) AT=90.025n

.meas tran vdout0_92ck170 FIND v(dout0_92) AT=90.025n

.meas tran vdout0_93ck170 FIND v(dout0_93) AT=90.025n

.meas tran vdout0_94ck170 FIND v(dout0_94) AT=90.025n

.meas tran vdout0_95ck170 FIND v(dout0_95) AT=90.025n

.meas tran vdout0_96ck170 FIND v(dout0_96) AT=90.025n

.meas tran vdout0_97ck170 FIND v(dout0_97) AT=90.025n

.meas tran vdout0_98ck170 FIND v(dout0_98) AT=90.025n

.meas tran vdout0_99ck170 FIND v(dout0_99) AT=90.025n

.meas tran vdout0_100ck170 FIND v(dout0_100) AT=90.025n

.meas tran vdout0_101ck170 FIND v(dout0_101) AT=90.025n

.meas tran vdout0_102ck170 FIND v(dout0_102) AT=90.025n

.meas tran vdout0_103ck170 FIND v(dout0_103) AT=90.025n

.meas tran vdout0_104ck170 FIND v(dout0_104) AT=90.025n

.meas tran vdout0_105ck170 FIND v(dout0_105) AT=90.025n

.meas tran vdout0_106ck170 FIND v(dout0_106) AT=90.025n

.meas tran vdout0_107ck170 FIND v(dout0_107) AT=90.025n

.meas tran vdout0_108ck170 FIND v(dout0_108) AT=90.025n

.meas tran vdout0_109ck170 FIND v(dout0_109) AT=90.025n

.meas tran vdout0_110ck170 FIND v(dout0_110) AT=90.025n

.meas tran vdout0_111ck170 FIND v(dout0_111) AT=90.025n

.meas tran vdout0_112ck170 FIND v(dout0_112) AT=90.025n

.meas tran vdout0_113ck170 FIND v(dout0_113) AT=90.025n

.meas tran vdout0_114ck170 FIND v(dout0_114) AT=90.025n

.meas tran vdout0_115ck170 FIND v(dout0_115) AT=90.025n

.meas tran vdout0_116ck170 FIND v(dout0_116) AT=90.025n

.meas tran vdout0_117ck170 FIND v(dout0_117) AT=90.025n

.meas tran vdout0_118ck170 FIND v(dout0_118) AT=90.025n

.meas tran vdout0_119ck170 FIND v(dout0_119) AT=90.025n

.meas tran vdout0_120ck170 FIND v(dout0_120) AT=90.025n

.meas tran vdout0_121ck170 FIND v(dout0_121) AT=90.025n

.meas tran vdout0_122ck170 FIND v(dout0_122) AT=90.025n

.meas tran vdout0_123ck170 FIND v(dout0_123) AT=90.025n

.meas tran vdout0_124ck170 FIND v(dout0_124) AT=90.025n

.meas tran vdout0_125ck170 FIND v(dout0_125) AT=90.025n

.meas tran vdout0_126ck170 FIND v(dout0_126) AT=90.025n

.meas tran vdout0_127ck170 FIND v(dout0_127) AT=90.025n

.meas tran vdout0_0ck180 FIND v(dout0_0) AT=95.025n

.meas tran vdout0_1ck180 FIND v(dout0_1) AT=95.025n

.meas tran vdout0_2ck180 FIND v(dout0_2) AT=95.025n

.meas tran vdout0_3ck180 FIND v(dout0_3) AT=95.025n

.meas tran vdout0_4ck180 FIND v(dout0_4) AT=95.025n

.meas tran vdout0_5ck180 FIND v(dout0_5) AT=95.025n

.meas tran vdout0_6ck180 FIND v(dout0_6) AT=95.025n

.meas tran vdout0_7ck180 FIND v(dout0_7) AT=95.025n

.meas tran vdout0_8ck180 FIND v(dout0_8) AT=95.025n

.meas tran vdout0_9ck180 FIND v(dout0_9) AT=95.025n

.meas tran vdout0_10ck180 FIND v(dout0_10) AT=95.025n

.meas tran vdout0_11ck180 FIND v(dout0_11) AT=95.025n

.meas tran vdout0_12ck180 FIND v(dout0_12) AT=95.025n

.meas tran vdout0_13ck180 FIND v(dout0_13) AT=95.025n

.meas tran vdout0_14ck180 FIND v(dout0_14) AT=95.025n

.meas tran vdout0_15ck180 FIND v(dout0_15) AT=95.025n

.meas tran vdout0_16ck180 FIND v(dout0_16) AT=95.025n

.meas tran vdout0_17ck180 FIND v(dout0_17) AT=95.025n

.meas tran vdout0_18ck180 FIND v(dout0_18) AT=95.025n

.meas tran vdout0_19ck180 FIND v(dout0_19) AT=95.025n

.meas tran vdout0_20ck180 FIND v(dout0_20) AT=95.025n

.meas tran vdout0_21ck180 FIND v(dout0_21) AT=95.025n

.meas tran vdout0_22ck180 FIND v(dout0_22) AT=95.025n

.meas tran vdout0_23ck180 FIND v(dout0_23) AT=95.025n

.meas tran vdout0_24ck180 FIND v(dout0_24) AT=95.025n

.meas tran vdout0_25ck180 FIND v(dout0_25) AT=95.025n

.meas tran vdout0_26ck180 FIND v(dout0_26) AT=95.025n

.meas tran vdout0_27ck180 FIND v(dout0_27) AT=95.025n

.meas tran vdout0_28ck180 FIND v(dout0_28) AT=95.025n

.meas tran vdout0_29ck180 FIND v(dout0_29) AT=95.025n

.meas tran vdout0_30ck180 FIND v(dout0_30) AT=95.025n

.meas tran vdout0_31ck180 FIND v(dout0_31) AT=95.025n

.meas tran vdout0_32ck180 FIND v(dout0_32) AT=95.025n

.meas tran vdout0_33ck180 FIND v(dout0_33) AT=95.025n

.meas tran vdout0_34ck180 FIND v(dout0_34) AT=95.025n

.meas tran vdout0_35ck180 FIND v(dout0_35) AT=95.025n

.meas tran vdout0_36ck180 FIND v(dout0_36) AT=95.025n

.meas tran vdout0_37ck180 FIND v(dout0_37) AT=95.025n

.meas tran vdout0_38ck180 FIND v(dout0_38) AT=95.025n

.meas tran vdout0_39ck180 FIND v(dout0_39) AT=95.025n

.meas tran vdout0_40ck180 FIND v(dout0_40) AT=95.025n

.meas tran vdout0_41ck180 FIND v(dout0_41) AT=95.025n

.meas tran vdout0_42ck180 FIND v(dout0_42) AT=95.025n

.meas tran vdout0_43ck180 FIND v(dout0_43) AT=95.025n

.meas tran vdout0_44ck180 FIND v(dout0_44) AT=95.025n

.meas tran vdout0_45ck180 FIND v(dout0_45) AT=95.025n

.meas tran vdout0_46ck180 FIND v(dout0_46) AT=95.025n

.meas tran vdout0_47ck180 FIND v(dout0_47) AT=95.025n

.meas tran vdout0_48ck180 FIND v(dout0_48) AT=95.025n

.meas tran vdout0_49ck180 FIND v(dout0_49) AT=95.025n

.meas tran vdout0_50ck180 FIND v(dout0_50) AT=95.025n

.meas tran vdout0_51ck180 FIND v(dout0_51) AT=95.025n

.meas tran vdout0_52ck180 FIND v(dout0_52) AT=95.025n

.meas tran vdout0_53ck180 FIND v(dout0_53) AT=95.025n

.meas tran vdout0_54ck180 FIND v(dout0_54) AT=95.025n

.meas tran vdout0_55ck180 FIND v(dout0_55) AT=95.025n

.meas tran vdout0_56ck180 FIND v(dout0_56) AT=95.025n

.meas tran vdout0_57ck180 FIND v(dout0_57) AT=95.025n

.meas tran vdout0_58ck180 FIND v(dout0_58) AT=95.025n

.meas tran vdout0_59ck180 FIND v(dout0_59) AT=95.025n

.meas tran vdout0_60ck180 FIND v(dout0_60) AT=95.025n

.meas tran vdout0_61ck180 FIND v(dout0_61) AT=95.025n

.meas tran vdout0_62ck180 FIND v(dout0_62) AT=95.025n

.meas tran vdout0_63ck180 FIND v(dout0_63) AT=95.025n

.meas tran vdout0_64ck180 FIND v(dout0_64) AT=95.025n

.meas tran vdout0_65ck180 FIND v(dout0_65) AT=95.025n

.meas tran vdout0_66ck180 FIND v(dout0_66) AT=95.025n

.meas tran vdout0_67ck180 FIND v(dout0_67) AT=95.025n

.meas tran vdout0_68ck180 FIND v(dout0_68) AT=95.025n

.meas tran vdout0_69ck180 FIND v(dout0_69) AT=95.025n

.meas tran vdout0_70ck180 FIND v(dout0_70) AT=95.025n

.meas tran vdout0_71ck180 FIND v(dout0_71) AT=95.025n

.meas tran vdout0_72ck180 FIND v(dout0_72) AT=95.025n

.meas tran vdout0_73ck180 FIND v(dout0_73) AT=95.025n

.meas tran vdout0_74ck180 FIND v(dout0_74) AT=95.025n

.meas tran vdout0_75ck180 FIND v(dout0_75) AT=95.025n

.meas tran vdout0_76ck180 FIND v(dout0_76) AT=95.025n

.meas tran vdout0_77ck180 FIND v(dout0_77) AT=95.025n

.meas tran vdout0_78ck180 FIND v(dout0_78) AT=95.025n

.meas tran vdout0_79ck180 FIND v(dout0_79) AT=95.025n

.meas tran vdout0_80ck180 FIND v(dout0_80) AT=95.025n

.meas tran vdout0_81ck180 FIND v(dout0_81) AT=95.025n

.meas tran vdout0_82ck180 FIND v(dout0_82) AT=95.025n

.meas tran vdout0_83ck180 FIND v(dout0_83) AT=95.025n

.meas tran vdout0_84ck180 FIND v(dout0_84) AT=95.025n

.meas tran vdout0_85ck180 FIND v(dout0_85) AT=95.025n

.meas tran vdout0_86ck180 FIND v(dout0_86) AT=95.025n

.meas tran vdout0_87ck180 FIND v(dout0_87) AT=95.025n

.meas tran vdout0_88ck180 FIND v(dout0_88) AT=95.025n

.meas tran vdout0_89ck180 FIND v(dout0_89) AT=95.025n

.meas tran vdout0_90ck180 FIND v(dout0_90) AT=95.025n

.meas tran vdout0_91ck180 FIND v(dout0_91) AT=95.025n

.meas tran vdout0_92ck180 FIND v(dout0_92) AT=95.025n

.meas tran vdout0_93ck180 FIND v(dout0_93) AT=95.025n

.meas tran vdout0_94ck180 FIND v(dout0_94) AT=95.025n

.meas tran vdout0_95ck180 FIND v(dout0_95) AT=95.025n

.meas tran vdout0_96ck180 FIND v(dout0_96) AT=95.025n

.meas tran vdout0_97ck180 FIND v(dout0_97) AT=95.025n

.meas tran vdout0_98ck180 FIND v(dout0_98) AT=95.025n

.meas tran vdout0_99ck180 FIND v(dout0_99) AT=95.025n

.meas tran vdout0_100ck180 FIND v(dout0_100) AT=95.025n

.meas tran vdout0_101ck180 FIND v(dout0_101) AT=95.025n

.meas tran vdout0_102ck180 FIND v(dout0_102) AT=95.025n

.meas tran vdout0_103ck180 FIND v(dout0_103) AT=95.025n

.meas tran vdout0_104ck180 FIND v(dout0_104) AT=95.025n

.meas tran vdout0_105ck180 FIND v(dout0_105) AT=95.025n

.meas tran vdout0_106ck180 FIND v(dout0_106) AT=95.025n

.meas tran vdout0_107ck180 FIND v(dout0_107) AT=95.025n

.meas tran vdout0_108ck180 FIND v(dout0_108) AT=95.025n

.meas tran vdout0_109ck180 FIND v(dout0_109) AT=95.025n

.meas tran vdout0_110ck180 FIND v(dout0_110) AT=95.025n

.meas tran vdout0_111ck180 FIND v(dout0_111) AT=95.025n

.meas tran vdout0_112ck180 FIND v(dout0_112) AT=95.025n

.meas tran vdout0_113ck180 FIND v(dout0_113) AT=95.025n

.meas tran vdout0_114ck180 FIND v(dout0_114) AT=95.025n

.meas tran vdout0_115ck180 FIND v(dout0_115) AT=95.025n

.meas tran vdout0_116ck180 FIND v(dout0_116) AT=95.025n

.meas tran vdout0_117ck180 FIND v(dout0_117) AT=95.025n

.meas tran vdout0_118ck180 FIND v(dout0_118) AT=95.025n

.meas tran vdout0_119ck180 FIND v(dout0_119) AT=95.025n

.meas tran vdout0_120ck180 FIND v(dout0_120) AT=95.025n

.meas tran vdout0_121ck180 FIND v(dout0_121) AT=95.025n

.meas tran vdout0_122ck180 FIND v(dout0_122) AT=95.025n

.meas tran vdout0_123ck180 FIND v(dout0_123) AT=95.025n

.meas tran vdout0_124ck180 FIND v(dout0_124) AT=95.025n

.meas tran vdout0_125ck180 FIND v(dout0_125) AT=95.025n

.meas tran vdout0_126ck180 FIND v(dout0_126) AT=95.025n

.meas tran vdout0_127ck180 FIND v(dout0_127) AT=95.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_0ck210 FIND v(dout0_0) AT=110.025n

.meas tran vdout0_1ck210 FIND v(dout0_1) AT=110.025n

.meas tran vdout0_2ck210 FIND v(dout0_2) AT=110.025n

.meas tran vdout0_3ck210 FIND v(dout0_3) AT=110.025n

.meas tran vdout0_4ck210 FIND v(dout0_4) AT=110.025n

.meas tran vdout0_5ck210 FIND v(dout0_5) AT=110.025n

.meas tran vdout0_6ck210 FIND v(dout0_6) AT=110.025n

.meas tran vdout0_7ck210 FIND v(dout0_7) AT=110.025n

.meas tran vdout0_8ck210 FIND v(dout0_8) AT=110.025n

.meas tran vdout0_9ck210 FIND v(dout0_9) AT=110.025n

.meas tran vdout0_10ck210 FIND v(dout0_10) AT=110.025n

.meas tran vdout0_11ck210 FIND v(dout0_11) AT=110.025n

.meas tran vdout0_12ck210 FIND v(dout0_12) AT=110.025n

.meas tran vdout0_13ck210 FIND v(dout0_13) AT=110.025n

.meas tran vdout0_14ck210 FIND v(dout0_14) AT=110.025n

.meas tran vdout0_15ck210 FIND v(dout0_15) AT=110.025n

.meas tran vdout0_16ck210 FIND v(dout0_16) AT=110.025n

.meas tran vdout0_17ck210 FIND v(dout0_17) AT=110.025n

.meas tran vdout0_18ck210 FIND v(dout0_18) AT=110.025n

.meas tran vdout0_19ck210 FIND v(dout0_19) AT=110.025n

.meas tran vdout0_20ck210 FIND v(dout0_20) AT=110.025n

.meas tran vdout0_21ck210 FIND v(dout0_21) AT=110.025n

.meas tran vdout0_22ck210 FIND v(dout0_22) AT=110.025n

.meas tran vdout0_23ck210 FIND v(dout0_23) AT=110.025n

.meas tran vdout0_24ck210 FIND v(dout0_24) AT=110.025n

.meas tran vdout0_25ck210 FIND v(dout0_25) AT=110.025n

.meas tran vdout0_26ck210 FIND v(dout0_26) AT=110.025n

.meas tran vdout0_27ck210 FIND v(dout0_27) AT=110.025n

.meas tran vdout0_28ck210 FIND v(dout0_28) AT=110.025n

.meas tran vdout0_29ck210 FIND v(dout0_29) AT=110.025n

.meas tran vdout0_30ck210 FIND v(dout0_30) AT=110.025n

.meas tran vdout0_31ck210 FIND v(dout0_31) AT=110.025n

.meas tran vdout0_32ck210 FIND v(dout0_32) AT=110.025n

.meas tran vdout0_33ck210 FIND v(dout0_33) AT=110.025n

.meas tran vdout0_34ck210 FIND v(dout0_34) AT=110.025n

.meas tran vdout0_35ck210 FIND v(dout0_35) AT=110.025n

.meas tran vdout0_36ck210 FIND v(dout0_36) AT=110.025n

.meas tran vdout0_37ck210 FIND v(dout0_37) AT=110.025n

.meas tran vdout0_38ck210 FIND v(dout0_38) AT=110.025n

.meas tran vdout0_39ck210 FIND v(dout0_39) AT=110.025n

.meas tran vdout0_40ck210 FIND v(dout0_40) AT=110.025n

.meas tran vdout0_41ck210 FIND v(dout0_41) AT=110.025n

.meas tran vdout0_42ck210 FIND v(dout0_42) AT=110.025n

.meas tran vdout0_43ck210 FIND v(dout0_43) AT=110.025n

.meas tran vdout0_44ck210 FIND v(dout0_44) AT=110.025n

.meas tran vdout0_45ck210 FIND v(dout0_45) AT=110.025n

.meas tran vdout0_46ck210 FIND v(dout0_46) AT=110.025n

.meas tran vdout0_47ck210 FIND v(dout0_47) AT=110.025n

.meas tran vdout0_48ck210 FIND v(dout0_48) AT=110.025n

.meas tran vdout0_49ck210 FIND v(dout0_49) AT=110.025n

.meas tran vdout0_50ck210 FIND v(dout0_50) AT=110.025n

.meas tran vdout0_51ck210 FIND v(dout0_51) AT=110.025n

.meas tran vdout0_52ck210 FIND v(dout0_52) AT=110.025n

.meas tran vdout0_53ck210 FIND v(dout0_53) AT=110.025n

.meas tran vdout0_54ck210 FIND v(dout0_54) AT=110.025n

.meas tran vdout0_55ck210 FIND v(dout0_55) AT=110.025n

.meas tran vdout0_56ck210 FIND v(dout0_56) AT=110.025n

.meas tran vdout0_57ck210 FIND v(dout0_57) AT=110.025n

.meas tran vdout0_58ck210 FIND v(dout0_58) AT=110.025n

.meas tran vdout0_59ck210 FIND v(dout0_59) AT=110.025n

.meas tran vdout0_60ck210 FIND v(dout0_60) AT=110.025n

.meas tran vdout0_61ck210 FIND v(dout0_61) AT=110.025n

.meas tran vdout0_62ck210 FIND v(dout0_62) AT=110.025n

.meas tran vdout0_63ck210 FIND v(dout0_63) AT=110.025n

.meas tran vdout0_64ck210 FIND v(dout0_64) AT=110.025n

.meas tran vdout0_65ck210 FIND v(dout0_65) AT=110.025n

.meas tran vdout0_66ck210 FIND v(dout0_66) AT=110.025n

.meas tran vdout0_67ck210 FIND v(dout0_67) AT=110.025n

.meas tran vdout0_68ck210 FIND v(dout0_68) AT=110.025n

.meas tran vdout0_69ck210 FIND v(dout0_69) AT=110.025n

.meas tran vdout0_70ck210 FIND v(dout0_70) AT=110.025n

.meas tran vdout0_71ck210 FIND v(dout0_71) AT=110.025n

.meas tran vdout0_72ck210 FIND v(dout0_72) AT=110.025n

.meas tran vdout0_73ck210 FIND v(dout0_73) AT=110.025n

.meas tran vdout0_74ck210 FIND v(dout0_74) AT=110.025n

.meas tran vdout0_75ck210 FIND v(dout0_75) AT=110.025n

.meas tran vdout0_76ck210 FIND v(dout0_76) AT=110.025n

.meas tran vdout0_77ck210 FIND v(dout0_77) AT=110.025n

.meas tran vdout0_78ck210 FIND v(dout0_78) AT=110.025n

.meas tran vdout0_79ck210 FIND v(dout0_79) AT=110.025n

.meas tran vdout0_80ck210 FIND v(dout0_80) AT=110.025n

.meas tran vdout0_81ck210 FIND v(dout0_81) AT=110.025n

.meas tran vdout0_82ck210 FIND v(dout0_82) AT=110.025n

.meas tran vdout0_83ck210 FIND v(dout0_83) AT=110.025n

.meas tran vdout0_84ck210 FIND v(dout0_84) AT=110.025n

.meas tran vdout0_85ck210 FIND v(dout0_85) AT=110.025n

.meas tran vdout0_86ck210 FIND v(dout0_86) AT=110.025n

.meas tran vdout0_87ck210 FIND v(dout0_87) AT=110.025n

.meas tran vdout0_88ck210 FIND v(dout0_88) AT=110.025n

.meas tran vdout0_89ck210 FIND v(dout0_89) AT=110.025n

.meas tran vdout0_90ck210 FIND v(dout0_90) AT=110.025n

.meas tran vdout0_91ck210 FIND v(dout0_91) AT=110.025n

.meas tran vdout0_92ck210 FIND v(dout0_92) AT=110.025n

.meas tran vdout0_93ck210 FIND v(dout0_93) AT=110.025n

.meas tran vdout0_94ck210 FIND v(dout0_94) AT=110.025n

.meas tran vdout0_95ck210 FIND v(dout0_95) AT=110.025n

.meas tran vdout0_96ck210 FIND v(dout0_96) AT=110.025n

.meas tran vdout0_97ck210 FIND v(dout0_97) AT=110.025n

.meas tran vdout0_98ck210 FIND v(dout0_98) AT=110.025n

.meas tran vdout0_99ck210 FIND v(dout0_99) AT=110.025n

.meas tran vdout0_100ck210 FIND v(dout0_100) AT=110.025n

.meas tran vdout0_101ck210 FIND v(dout0_101) AT=110.025n

.meas tran vdout0_102ck210 FIND v(dout0_102) AT=110.025n

.meas tran vdout0_103ck210 FIND v(dout0_103) AT=110.025n

.meas tran vdout0_104ck210 FIND v(dout0_104) AT=110.025n

.meas tran vdout0_105ck210 FIND v(dout0_105) AT=110.025n

.meas tran vdout0_106ck210 FIND v(dout0_106) AT=110.025n

.meas tran vdout0_107ck210 FIND v(dout0_107) AT=110.025n

.meas tran vdout0_108ck210 FIND v(dout0_108) AT=110.025n

.meas tran vdout0_109ck210 FIND v(dout0_109) AT=110.025n

.meas tran vdout0_110ck210 FIND v(dout0_110) AT=110.025n

.meas tran vdout0_111ck210 FIND v(dout0_111) AT=110.025n

.meas tran vdout0_112ck210 FIND v(dout0_112) AT=110.025n

.meas tran vdout0_113ck210 FIND v(dout0_113) AT=110.025n

.meas tran vdout0_114ck210 FIND v(dout0_114) AT=110.025n

.meas tran vdout0_115ck210 FIND v(dout0_115) AT=110.025n

.meas tran vdout0_116ck210 FIND v(dout0_116) AT=110.025n

.meas tran vdout0_117ck210 FIND v(dout0_117) AT=110.025n

.meas tran vdout0_118ck210 FIND v(dout0_118) AT=110.025n

.meas tran vdout0_119ck210 FIND v(dout0_119) AT=110.025n

.meas tran vdout0_120ck210 FIND v(dout0_120) AT=110.025n

.meas tran vdout0_121ck210 FIND v(dout0_121) AT=110.025n

.meas tran vdout0_122ck210 FIND v(dout0_122) AT=110.025n

.meas tran vdout0_123ck210 FIND v(dout0_123) AT=110.025n

.meas tran vdout0_124ck210 FIND v(dout0_124) AT=110.025n

.meas tran vdout0_125ck210 FIND v(dout0_125) AT=110.025n

.meas tran vdout0_126ck210 FIND v(dout0_126) AT=110.025n

.meas tran vdout0_127ck210 FIND v(dout0_127) AT=110.025n

.meas tran vdout0_0ck220 FIND v(dout0_0) AT=115.025n

.meas tran vdout0_1ck220 FIND v(dout0_1) AT=115.025n

.meas tran vdout0_2ck220 FIND v(dout0_2) AT=115.025n

.meas tran vdout0_3ck220 FIND v(dout0_3) AT=115.025n

.meas tran vdout0_4ck220 FIND v(dout0_4) AT=115.025n

.meas tran vdout0_5ck220 FIND v(dout0_5) AT=115.025n

.meas tran vdout0_6ck220 FIND v(dout0_6) AT=115.025n

.meas tran vdout0_7ck220 FIND v(dout0_7) AT=115.025n

.meas tran vdout0_8ck220 FIND v(dout0_8) AT=115.025n

.meas tran vdout0_9ck220 FIND v(dout0_9) AT=115.025n

.meas tran vdout0_10ck220 FIND v(dout0_10) AT=115.025n

.meas tran vdout0_11ck220 FIND v(dout0_11) AT=115.025n

.meas tran vdout0_12ck220 FIND v(dout0_12) AT=115.025n

.meas tran vdout0_13ck220 FIND v(dout0_13) AT=115.025n

.meas tran vdout0_14ck220 FIND v(dout0_14) AT=115.025n

.meas tran vdout0_15ck220 FIND v(dout0_15) AT=115.025n

.meas tran vdout0_16ck220 FIND v(dout0_16) AT=115.025n

.meas tran vdout0_17ck220 FIND v(dout0_17) AT=115.025n

.meas tran vdout0_18ck220 FIND v(dout0_18) AT=115.025n

.meas tran vdout0_19ck220 FIND v(dout0_19) AT=115.025n

.meas tran vdout0_20ck220 FIND v(dout0_20) AT=115.025n

.meas tran vdout0_21ck220 FIND v(dout0_21) AT=115.025n

.meas tran vdout0_22ck220 FIND v(dout0_22) AT=115.025n

.meas tran vdout0_23ck220 FIND v(dout0_23) AT=115.025n

.meas tran vdout0_24ck220 FIND v(dout0_24) AT=115.025n

.meas tran vdout0_25ck220 FIND v(dout0_25) AT=115.025n

.meas tran vdout0_26ck220 FIND v(dout0_26) AT=115.025n

.meas tran vdout0_27ck220 FIND v(dout0_27) AT=115.025n

.meas tran vdout0_28ck220 FIND v(dout0_28) AT=115.025n

.meas tran vdout0_29ck220 FIND v(dout0_29) AT=115.025n

.meas tran vdout0_30ck220 FIND v(dout0_30) AT=115.025n

.meas tran vdout0_31ck220 FIND v(dout0_31) AT=115.025n

.meas tran vdout0_32ck220 FIND v(dout0_32) AT=115.025n

.meas tran vdout0_33ck220 FIND v(dout0_33) AT=115.025n

.meas tran vdout0_34ck220 FIND v(dout0_34) AT=115.025n

.meas tran vdout0_35ck220 FIND v(dout0_35) AT=115.025n

.meas tran vdout0_36ck220 FIND v(dout0_36) AT=115.025n

.meas tran vdout0_37ck220 FIND v(dout0_37) AT=115.025n

.meas tran vdout0_38ck220 FIND v(dout0_38) AT=115.025n

.meas tran vdout0_39ck220 FIND v(dout0_39) AT=115.025n

.meas tran vdout0_40ck220 FIND v(dout0_40) AT=115.025n

.meas tran vdout0_41ck220 FIND v(dout0_41) AT=115.025n

.meas tran vdout0_42ck220 FIND v(dout0_42) AT=115.025n

.meas tran vdout0_43ck220 FIND v(dout0_43) AT=115.025n

.meas tran vdout0_44ck220 FIND v(dout0_44) AT=115.025n

.meas tran vdout0_45ck220 FIND v(dout0_45) AT=115.025n

.meas tran vdout0_46ck220 FIND v(dout0_46) AT=115.025n

.meas tran vdout0_47ck220 FIND v(dout0_47) AT=115.025n

.meas tran vdout0_48ck220 FIND v(dout0_48) AT=115.025n

.meas tran vdout0_49ck220 FIND v(dout0_49) AT=115.025n

.meas tran vdout0_50ck220 FIND v(dout0_50) AT=115.025n

.meas tran vdout0_51ck220 FIND v(dout0_51) AT=115.025n

.meas tran vdout0_52ck220 FIND v(dout0_52) AT=115.025n

.meas tran vdout0_53ck220 FIND v(dout0_53) AT=115.025n

.meas tran vdout0_54ck220 FIND v(dout0_54) AT=115.025n

.meas tran vdout0_55ck220 FIND v(dout0_55) AT=115.025n

.meas tran vdout0_56ck220 FIND v(dout0_56) AT=115.025n

.meas tran vdout0_57ck220 FIND v(dout0_57) AT=115.025n

.meas tran vdout0_58ck220 FIND v(dout0_58) AT=115.025n

.meas tran vdout0_59ck220 FIND v(dout0_59) AT=115.025n

.meas tran vdout0_60ck220 FIND v(dout0_60) AT=115.025n

.meas tran vdout0_61ck220 FIND v(dout0_61) AT=115.025n

.meas tran vdout0_62ck220 FIND v(dout0_62) AT=115.025n

.meas tran vdout0_63ck220 FIND v(dout0_63) AT=115.025n

.meas tran vdout0_64ck220 FIND v(dout0_64) AT=115.025n

.meas tran vdout0_65ck220 FIND v(dout0_65) AT=115.025n

.meas tran vdout0_66ck220 FIND v(dout0_66) AT=115.025n

.meas tran vdout0_67ck220 FIND v(dout0_67) AT=115.025n

.meas tran vdout0_68ck220 FIND v(dout0_68) AT=115.025n

.meas tran vdout0_69ck220 FIND v(dout0_69) AT=115.025n

.meas tran vdout0_70ck220 FIND v(dout0_70) AT=115.025n

.meas tran vdout0_71ck220 FIND v(dout0_71) AT=115.025n

.meas tran vdout0_72ck220 FIND v(dout0_72) AT=115.025n

.meas tran vdout0_73ck220 FIND v(dout0_73) AT=115.025n

.meas tran vdout0_74ck220 FIND v(dout0_74) AT=115.025n

.meas tran vdout0_75ck220 FIND v(dout0_75) AT=115.025n

.meas tran vdout0_76ck220 FIND v(dout0_76) AT=115.025n

.meas tran vdout0_77ck220 FIND v(dout0_77) AT=115.025n

.meas tran vdout0_78ck220 FIND v(dout0_78) AT=115.025n

.meas tran vdout0_79ck220 FIND v(dout0_79) AT=115.025n

.meas tran vdout0_80ck220 FIND v(dout0_80) AT=115.025n

.meas tran vdout0_81ck220 FIND v(dout0_81) AT=115.025n

.meas tran vdout0_82ck220 FIND v(dout0_82) AT=115.025n

.meas tran vdout0_83ck220 FIND v(dout0_83) AT=115.025n

.meas tran vdout0_84ck220 FIND v(dout0_84) AT=115.025n

.meas tran vdout0_85ck220 FIND v(dout0_85) AT=115.025n

.meas tran vdout0_86ck220 FIND v(dout0_86) AT=115.025n

.meas tran vdout0_87ck220 FIND v(dout0_87) AT=115.025n

.meas tran vdout0_88ck220 FIND v(dout0_88) AT=115.025n

.meas tran vdout0_89ck220 FIND v(dout0_89) AT=115.025n

.meas tran vdout0_90ck220 FIND v(dout0_90) AT=115.025n

.meas tran vdout0_91ck220 FIND v(dout0_91) AT=115.025n

.meas tran vdout0_92ck220 FIND v(dout0_92) AT=115.025n

.meas tran vdout0_93ck220 FIND v(dout0_93) AT=115.025n

.meas tran vdout0_94ck220 FIND v(dout0_94) AT=115.025n

.meas tran vdout0_95ck220 FIND v(dout0_95) AT=115.025n

.meas tran vdout0_96ck220 FIND v(dout0_96) AT=115.025n

.meas tran vdout0_97ck220 FIND v(dout0_97) AT=115.025n

.meas tran vdout0_98ck220 FIND v(dout0_98) AT=115.025n

.meas tran vdout0_99ck220 FIND v(dout0_99) AT=115.025n

.meas tran vdout0_100ck220 FIND v(dout0_100) AT=115.025n

.meas tran vdout0_101ck220 FIND v(dout0_101) AT=115.025n

.meas tran vdout0_102ck220 FIND v(dout0_102) AT=115.025n

.meas tran vdout0_103ck220 FIND v(dout0_103) AT=115.025n

.meas tran vdout0_104ck220 FIND v(dout0_104) AT=115.025n

.meas tran vdout0_105ck220 FIND v(dout0_105) AT=115.025n

.meas tran vdout0_106ck220 FIND v(dout0_106) AT=115.025n

.meas tran vdout0_107ck220 FIND v(dout0_107) AT=115.025n

.meas tran vdout0_108ck220 FIND v(dout0_108) AT=115.025n

.meas tran vdout0_109ck220 FIND v(dout0_109) AT=115.025n

.meas tran vdout0_110ck220 FIND v(dout0_110) AT=115.025n

.meas tran vdout0_111ck220 FIND v(dout0_111) AT=115.025n

.meas tran vdout0_112ck220 FIND v(dout0_112) AT=115.025n

.meas tran vdout0_113ck220 FIND v(dout0_113) AT=115.025n

.meas tran vdout0_114ck220 FIND v(dout0_114) AT=115.025n

.meas tran vdout0_115ck220 FIND v(dout0_115) AT=115.025n

.meas tran vdout0_116ck220 FIND v(dout0_116) AT=115.025n

.meas tran vdout0_117ck220 FIND v(dout0_117) AT=115.025n

.meas tran vdout0_118ck220 FIND v(dout0_118) AT=115.025n

.meas tran vdout0_119ck220 FIND v(dout0_119) AT=115.025n

.meas tran vdout0_120ck220 FIND v(dout0_120) AT=115.025n

.meas tran vdout0_121ck220 FIND v(dout0_121) AT=115.025n

.meas tran vdout0_122ck220 FIND v(dout0_122) AT=115.025n

.meas tran vdout0_123ck220 FIND v(dout0_123) AT=115.025n

.meas tran vdout0_124ck220 FIND v(dout0_124) AT=115.025n

.meas tran vdout0_125ck220 FIND v(dout0_125) AT=115.025n

.meas tran vdout0_126ck220 FIND v(dout0_126) AT=115.025n

.meas tran vdout0_127ck220 FIND v(dout0_127) AT=115.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_0ck270 FIND v(dout0_0) AT=140.025n

.meas tran vdout0_1ck270 FIND v(dout0_1) AT=140.025n

.meas tran vdout0_2ck270 FIND v(dout0_2) AT=140.025n

.meas tran vdout0_3ck270 FIND v(dout0_3) AT=140.025n

.meas tran vdout0_4ck270 FIND v(dout0_4) AT=140.025n

.meas tran vdout0_5ck270 FIND v(dout0_5) AT=140.025n

.meas tran vdout0_6ck270 FIND v(dout0_6) AT=140.025n

.meas tran vdout0_7ck270 FIND v(dout0_7) AT=140.025n

.meas tran vdout0_8ck270 FIND v(dout0_8) AT=140.025n

.meas tran vdout0_9ck270 FIND v(dout0_9) AT=140.025n

.meas tran vdout0_10ck270 FIND v(dout0_10) AT=140.025n

.meas tran vdout0_11ck270 FIND v(dout0_11) AT=140.025n

.meas tran vdout0_12ck270 FIND v(dout0_12) AT=140.025n

.meas tran vdout0_13ck270 FIND v(dout0_13) AT=140.025n

.meas tran vdout0_14ck270 FIND v(dout0_14) AT=140.025n

.meas tran vdout0_15ck270 FIND v(dout0_15) AT=140.025n

.meas tran vdout0_16ck270 FIND v(dout0_16) AT=140.025n

.meas tran vdout0_17ck270 FIND v(dout0_17) AT=140.025n

.meas tran vdout0_18ck270 FIND v(dout0_18) AT=140.025n

.meas tran vdout0_19ck270 FIND v(dout0_19) AT=140.025n

.meas tran vdout0_20ck270 FIND v(dout0_20) AT=140.025n

.meas tran vdout0_21ck270 FIND v(dout0_21) AT=140.025n

.meas tran vdout0_22ck270 FIND v(dout0_22) AT=140.025n

.meas tran vdout0_23ck270 FIND v(dout0_23) AT=140.025n

.meas tran vdout0_24ck270 FIND v(dout0_24) AT=140.025n

.meas tran vdout0_25ck270 FIND v(dout0_25) AT=140.025n

.meas tran vdout0_26ck270 FIND v(dout0_26) AT=140.025n

.meas tran vdout0_27ck270 FIND v(dout0_27) AT=140.025n

.meas tran vdout0_28ck270 FIND v(dout0_28) AT=140.025n

.meas tran vdout0_29ck270 FIND v(dout0_29) AT=140.025n

.meas tran vdout0_30ck270 FIND v(dout0_30) AT=140.025n

.meas tran vdout0_31ck270 FIND v(dout0_31) AT=140.025n

.meas tran vdout0_32ck270 FIND v(dout0_32) AT=140.025n

.meas tran vdout0_33ck270 FIND v(dout0_33) AT=140.025n

.meas tran vdout0_34ck270 FIND v(dout0_34) AT=140.025n

.meas tran vdout0_35ck270 FIND v(dout0_35) AT=140.025n

.meas tran vdout0_36ck270 FIND v(dout0_36) AT=140.025n

.meas tran vdout0_37ck270 FIND v(dout0_37) AT=140.025n

.meas tran vdout0_38ck270 FIND v(dout0_38) AT=140.025n

.meas tran vdout0_39ck270 FIND v(dout0_39) AT=140.025n

.meas tran vdout0_40ck270 FIND v(dout0_40) AT=140.025n

.meas tran vdout0_41ck270 FIND v(dout0_41) AT=140.025n

.meas tran vdout0_42ck270 FIND v(dout0_42) AT=140.025n

.meas tran vdout0_43ck270 FIND v(dout0_43) AT=140.025n

.meas tran vdout0_44ck270 FIND v(dout0_44) AT=140.025n

.meas tran vdout0_45ck270 FIND v(dout0_45) AT=140.025n

.meas tran vdout0_46ck270 FIND v(dout0_46) AT=140.025n

.meas tran vdout0_47ck270 FIND v(dout0_47) AT=140.025n

.meas tran vdout0_48ck270 FIND v(dout0_48) AT=140.025n

.meas tran vdout0_49ck270 FIND v(dout0_49) AT=140.025n

.meas tran vdout0_50ck270 FIND v(dout0_50) AT=140.025n

.meas tran vdout0_51ck270 FIND v(dout0_51) AT=140.025n

.meas tran vdout0_52ck270 FIND v(dout0_52) AT=140.025n

.meas tran vdout0_53ck270 FIND v(dout0_53) AT=140.025n

.meas tran vdout0_54ck270 FIND v(dout0_54) AT=140.025n

.meas tran vdout0_55ck270 FIND v(dout0_55) AT=140.025n

.meas tran vdout0_56ck270 FIND v(dout0_56) AT=140.025n

.meas tran vdout0_57ck270 FIND v(dout0_57) AT=140.025n

.meas tran vdout0_58ck270 FIND v(dout0_58) AT=140.025n

.meas tran vdout0_59ck270 FIND v(dout0_59) AT=140.025n

.meas tran vdout0_60ck270 FIND v(dout0_60) AT=140.025n

.meas tran vdout0_61ck270 FIND v(dout0_61) AT=140.025n

.meas tran vdout0_62ck270 FIND v(dout0_62) AT=140.025n

.meas tran vdout0_63ck270 FIND v(dout0_63) AT=140.025n

.meas tran vdout0_64ck270 FIND v(dout0_64) AT=140.025n

.meas tran vdout0_65ck270 FIND v(dout0_65) AT=140.025n

.meas tran vdout0_66ck270 FIND v(dout0_66) AT=140.025n

.meas tran vdout0_67ck270 FIND v(dout0_67) AT=140.025n

.meas tran vdout0_68ck270 FIND v(dout0_68) AT=140.025n

.meas tran vdout0_69ck270 FIND v(dout0_69) AT=140.025n

.meas tran vdout0_70ck270 FIND v(dout0_70) AT=140.025n

.meas tran vdout0_71ck270 FIND v(dout0_71) AT=140.025n

.meas tran vdout0_72ck270 FIND v(dout0_72) AT=140.025n

.meas tran vdout0_73ck270 FIND v(dout0_73) AT=140.025n

.meas tran vdout0_74ck270 FIND v(dout0_74) AT=140.025n

.meas tran vdout0_75ck270 FIND v(dout0_75) AT=140.025n

.meas tran vdout0_76ck270 FIND v(dout0_76) AT=140.025n

.meas tran vdout0_77ck270 FIND v(dout0_77) AT=140.025n

.meas tran vdout0_78ck270 FIND v(dout0_78) AT=140.025n

.meas tran vdout0_79ck270 FIND v(dout0_79) AT=140.025n

.meas tran vdout0_80ck270 FIND v(dout0_80) AT=140.025n

.meas tran vdout0_81ck270 FIND v(dout0_81) AT=140.025n

.meas tran vdout0_82ck270 FIND v(dout0_82) AT=140.025n

.meas tran vdout0_83ck270 FIND v(dout0_83) AT=140.025n

.meas tran vdout0_84ck270 FIND v(dout0_84) AT=140.025n

.meas tran vdout0_85ck270 FIND v(dout0_85) AT=140.025n

.meas tran vdout0_86ck270 FIND v(dout0_86) AT=140.025n

.meas tran vdout0_87ck270 FIND v(dout0_87) AT=140.025n

.meas tran vdout0_88ck270 FIND v(dout0_88) AT=140.025n

.meas tran vdout0_89ck270 FIND v(dout0_89) AT=140.025n

.meas tran vdout0_90ck270 FIND v(dout0_90) AT=140.025n

.meas tran vdout0_91ck270 FIND v(dout0_91) AT=140.025n

.meas tran vdout0_92ck270 FIND v(dout0_92) AT=140.025n

.meas tran vdout0_93ck270 FIND v(dout0_93) AT=140.025n

.meas tran vdout0_94ck270 FIND v(dout0_94) AT=140.025n

.meas tran vdout0_95ck270 FIND v(dout0_95) AT=140.025n

.meas tran vdout0_96ck270 FIND v(dout0_96) AT=140.025n

.meas tran vdout0_97ck270 FIND v(dout0_97) AT=140.025n

.meas tran vdout0_98ck270 FIND v(dout0_98) AT=140.025n

.meas tran vdout0_99ck270 FIND v(dout0_99) AT=140.025n

.meas tran vdout0_100ck270 FIND v(dout0_100) AT=140.025n

.meas tran vdout0_101ck270 FIND v(dout0_101) AT=140.025n

.meas tran vdout0_102ck270 FIND v(dout0_102) AT=140.025n

.meas tran vdout0_103ck270 FIND v(dout0_103) AT=140.025n

.meas tran vdout0_104ck270 FIND v(dout0_104) AT=140.025n

.meas tran vdout0_105ck270 FIND v(dout0_105) AT=140.025n

.meas tran vdout0_106ck270 FIND v(dout0_106) AT=140.025n

.meas tran vdout0_107ck270 FIND v(dout0_107) AT=140.025n

.meas tran vdout0_108ck270 FIND v(dout0_108) AT=140.025n

.meas tran vdout0_109ck270 FIND v(dout0_109) AT=140.025n

.meas tran vdout0_110ck270 FIND v(dout0_110) AT=140.025n

.meas tran vdout0_111ck270 FIND v(dout0_111) AT=140.025n

.meas tran vdout0_112ck270 FIND v(dout0_112) AT=140.025n

.meas tran vdout0_113ck270 FIND v(dout0_113) AT=140.025n

.meas tran vdout0_114ck270 FIND v(dout0_114) AT=140.025n

.meas tran vdout0_115ck270 FIND v(dout0_115) AT=140.025n

.meas tran vdout0_116ck270 FIND v(dout0_116) AT=140.025n

.meas tran vdout0_117ck270 FIND v(dout0_117) AT=140.025n

.meas tran vdout0_118ck270 FIND v(dout0_118) AT=140.025n

.meas tran vdout0_119ck270 FIND v(dout0_119) AT=140.025n

.meas tran vdout0_120ck270 FIND v(dout0_120) AT=140.025n

.meas tran vdout0_121ck270 FIND v(dout0_121) AT=140.025n

.meas tran vdout0_122ck270 FIND v(dout0_122) AT=140.025n

.meas tran vdout0_123ck270 FIND v(dout0_123) AT=140.025n

.meas tran vdout0_124ck270 FIND v(dout0_124) AT=140.025n

.meas tran vdout0_125ck270 FIND v(dout0_125) AT=140.025n

.meas tran vdout0_126ck270 FIND v(dout0_126) AT=140.025n

.meas tran vdout0_127ck270 FIND v(dout0_127) AT=140.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_0ck310 FIND v(dout0_0) AT=160.025n

.meas tran vdout0_1ck310 FIND v(dout0_1) AT=160.025n

.meas tran vdout0_2ck310 FIND v(dout0_2) AT=160.025n

.meas tran vdout0_3ck310 FIND v(dout0_3) AT=160.025n

.meas tran vdout0_4ck310 FIND v(dout0_4) AT=160.025n

.meas tran vdout0_5ck310 FIND v(dout0_5) AT=160.025n

.meas tran vdout0_6ck310 FIND v(dout0_6) AT=160.025n

.meas tran vdout0_7ck310 FIND v(dout0_7) AT=160.025n

.meas tran vdout0_8ck310 FIND v(dout0_8) AT=160.025n

.meas tran vdout0_9ck310 FIND v(dout0_9) AT=160.025n

.meas tran vdout0_10ck310 FIND v(dout0_10) AT=160.025n

.meas tran vdout0_11ck310 FIND v(dout0_11) AT=160.025n

.meas tran vdout0_12ck310 FIND v(dout0_12) AT=160.025n

.meas tran vdout0_13ck310 FIND v(dout0_13) AT=160.025n

.meas tran vdout0_14ck310 FIND v(dout0_14) AT=160.025n

.meas tran vdout0_15ck310 FIND v(dout0_15) AT=160.025n

.meas tran vdout0_16ck310 FIND v(dout0_16) AT=160.025n

.meas tran vdout0_17ck310 FIND v(dout0_17) AT=160.025n

.meas tran vdout0_18ck310 FIND v(dout0_18) AT=160.025n

.meas tran vdout0_19ck310 FIND v(dout0_19) AT=160.025n

.meas tran vdout0_20ck310 FIND v(dout0_20) AT=160.025n

.meas tran vdout0_21ck310 FIND v(dout0_21) AT=160.025n

.meas tran vdout0_22ck310 FIND v(dout0_22) AT=160.025n

.meas tran vdout0_23ck310 FIND v(dout0_23) AT=160.025n

.meas tran vdout0_24ck310 FIND v(dout0_24) AT=160.025n

.meas tran vdout0_25ck310 FIND v(dout0_25) AT=160.025n

.meas tran vdout0_26ck310 FIND v(dout0_26) AT=160.025n

.meas tran vdout0_27ck310 FIND v(dout0_27) AT=160.025n

.meas tran vdout0_28ck310 FIND v(dout0_28) AT=160.025n

.meas tran vdout0_29ck310 FIND v(dout0_29) AT=160.025n

.meas tran vdout0_30ck310 FIND v(dout0_30) AT=160.025n

.meas tran vdout0_31ck310 FIND v(dout0_31) AT=160.025n

.meas tran vdout0_32ck310 FIND v(dout0_32) AT=160.025n

.meas tran vdout0_33ck310 FIND v(dout0_33) AT=160.025n

.meas tran vdout0_34ck310 FIND v(dout0_34) AT=160.025n

.meas tran vdout0_35ck310 FIND v(dout0_35) AT=160.025n

.meas tran vdout0_36ck310 FIND v(dout0_36) AT=160.025n

.meas tran vdout0_37ck310 FIND v(dout0_37) AT=160.025n

.meas tran vdout0_38ck310 FIND v(dout0_38) AT=160.025n

.meas tran vdout0_39ck310 FIND v(dout0_39) AT=160.025n

.meas tran vdout0_40ck310 FIND v(dout0_40) AT=160.025n

.meas tran vdout0_41ck310 FIND v(dout0_41) AT=160.025n

.meas tran vdout0_42ck310 FIND v(dout0_42) AT=160.025n

.meas tran vdout0_43ck310 FIND v(dout0_43) AT=160.025n

.meas tran vdout0_44ck310 FIND v(dout0_44) AT=160.025n

.meas tran vdout0_45ck310 FIND v(dout0_45) AT=160.025n

.meas tran vdout0_46ck310 FIND v(dout0_46) AT=160.025n

.meas tran vdout0_47ck310 FIND v(dout0_47) AT=160.025n

.meas tran vdout0_48ck310 FIND v(dout0_48) AT=160.025n

.meas tran vdout0_49ck310 FIND v(dout0_49) AT=160.025n

.meas tran vdout0_50ck310 FIND v(dout0_50) AT=160.025n

.meas tran vdout0_51ck310 FIND v(dout0_51) AT=160.025n

.meas tran vdout0_52ck310 FIND v(dout0_52) AT=160.025n

.meas tran vdout0_53ck310 FIND v(dout0_53) AT=160.025n

.meas tran vdout0_54ck310 FIND v(dout0_54) AT=160.025n

.meas tran vdout0_55ck310 FIND v(dout0_55) AT=160.025n

.meas tran vdout0_56ck310 FIND v(dout0_56) AT=160.025n

.meas tran vdout0_57ck310 FIND v(dout0_57) AT=160.025n

.meas tran vdout0_58ck310 FIND v(dout0_58) AT=160.025n

.meas tran vdout0_59ck310 FIND v(dout0_59) AT=160.025n

.meas tran vdout0_60ck310 FIND v(dout0_60) AT=160.025n

.meas tran vdout0_61ck310 FIND v(dout0_61) AT=160.025n

.meas tran vdout0_62ck310 FIND v(dout0_62) AT=160.025n

.meas tran vdout0_63ck310 FIND v(dout0_63) AT=160.025n

.meas tran vdout0_64ck310 FIND v(dout0_64) AT=160.025n

.meas tran vdout0_65ck310 FIND v(dout0_65) AT=160.025n

.meas tran vdout0_66ck310 FIND v(dout0_66) AT=160.025n

.meas tran vdout0_67ck310 FIND v(dout0_67) AT=160.025n

.meas tran vdout0_68ck310 FIND v(dout0_68) AT=160.025n

.meas tran vdout0_69ck310 FIND v(dout0_69) AT=160.025n

.meas tran vdout0_70ck310 FIND v(dout0_70) AT=160.025n

.meas tran vdout0_71ck310 FIND v(dout0_71) AT=160.025n

.meas tran vdout0_72ck310 FIND v(dout0_72) AT=160.025n

.meas tran vdout0_73ck310 FIND v(dout0_73) AT=160.025n

.meas tran vdout0_74ck310 FIND v(dout0_74) AT=160.025n

.meas tran vdout0_75ck310 FIND v(dout0_75) AT=160.025n

.meas tran vdout0_76ck310 FIND v(dout0_76) AT=160.025n

.meas tran vdout0_77ck310 FIND v(dout0_77) AT=160.025n

.meas tran vdout0_78ck310 FIND v(dout0_78) AT=160.025n

.meas tran vdout0_79ck310 FIND v(dout0_79) AT=160.025n

.meas tran vdout0_80ck310 FIND v(dout0_80) AT=160.025n

.meas tran vdout0_81ck310 FIND v(dout0_81) AT=160.025n

.meas tran vdout0_82ck310 FIND v(dout0_82) AT=160.025n

.meas tran vdout0_83ck310 FIND v(dout0_83) AT=160.025n

.meas tran vdout0_84ck310 FIND v(dout0_84) AT=160.025n

.meas tran vdout0_85ck310 FIND v(dout0_85) AT=160.025n

.meas tran vdout0_86ck310 FIND v(dout0_86) AT=160.025n

.meas tran vdout0_87ck310 FIND v(dout0_87) AT=160.025n

.meas tran vdout0_88ck310 FIND v(dout0_88) AT=160.025n

.meas tran vdout0_89ck310 FIND v(dout0_89) AT=160.025n

.meas tran vdout0_90ck310 FIND v(dout0_90) AT=160.025n

.meas tran vdout0_91ck310 FIND v(dout0_91) AT=160.025n

.meas tran vdout0_92ck310 FIND v(dout0_92) AT=160.025n

.meas tran vdout0_93ck310 FIND v(dout0_93) AT=160.025n

.meas tran vdout0_94ck310 FIND v(dout0_94) AT=160.025n

.meas tran vdout0_95ck310 FIND v(dout0_95) AT=160.025n

.meas tran vdout0_96ck310 FIND v(dout0_96) AT=160.025n

.meas tran vdout0_97ck310 FIND v(dout0_97) AT=160.025n

.meas tran vdout0_98ck310 FIND v(dout0_98) AT=160.025n

.meas tran vdout0_99ck310 FIND v(dout0_99) AT=160.025n

.meas tran vdout0_100ck310 FIND v(dout0_100) AT=160.025n

.meas tran vdout0_101ck310 FIND v(dout0_101) AT=160.025n

.meas tran vdout0_102ck310 FIND v(dout0_102) AT=160.025n

.meas tran vdout0_103ck310 FIND v(dout0_103) AT=160.025n

.meas tran vdout0_104ck310 FIND v(dout0_104) AT=160.025n

.meas tran vdout0_105ck310 FIND v(dout0_105) AT=160.025n

.meas tran vdout0_106ck310 FIND v(dout0_106) AT=160.025n

.meas tran vdout0_107ck310 FIND v(dout0_107) AT=160.025n

.meas tran vdout0_108ck310 FIND v(dout0_108) AT=160.025n

.meas tran vdout0_109ck310 FIND v(dout0_109) AT=160.025n

.meas tran vdout0_110ck310 FIND v(dout0_110) AT=160.025n

.meas tran vdout0_111ck310 FIND v(dout0_111) AT=160.025n

.meas tran vdout0_112ck310 FIND v(dout0_112) AT=160.025n

.meas tran vdout0_113ck310 FIND v(dout0_113) AT=160.025n

.meas tran vdout0_114ck310 FIND v(dout0_114) AT=160.025n

.meas tran vdout0_115ck310 FIND v(dout0_115) AT=160.025n

.meas tran vdout0_116ck310 FIND v(dout0_116) AT=160.025n

.meas tran vdout0_117ck310 FIND v(dout0_117) AT=160.025n

.meas tran vdout0_118ck310 FIND v(dout0_118) AT=160.025n

.meas tran vdout0_119ck310 FIND v(dout0_119) AT=160.025n

.meas tran vdout0_120ck310 FIND v(dout0_120) AT=160.025n

.meas tran vdout0_121ck310 FIND v(dout0_121) AT=160.025n

.meas tran vdout0_122ck310 FIND v(dout0_122) AT=160.025n

.meas tran vdout0_123ck310 FIND v(dout0_123) AT=160.025n

.meas tran vdout0_124ck310 FIND v(dout0_124) AT=160.025n

.meas tran vdout0_125ck310 FIND v(dout0_125) AT=160.025n

.meas tran vdout0_126ck310 FIND v(dout0_126) AT=160.025n

.meas tran vdout0_127ck310 FIND v(dout0_127) AT=160.025n

.meas tran vdout0_0ck330 FIND v(dout0_0) AT=170.025n

.meas tran vdout0_1ck330 FIND v(dout0_1) AT=170.025n

.meas tran vdout0_2ck330 FIND v(dout0_2) AT=170.025n

.meas tran vdout0_3ck330 FIND v(dout0_3) AT=170.025n

.meas tran vdout0_4ck330 FIND v(dout0_4) AT=170.025n

.meas tran vdout0_5ck330 FIND v(dout0_5) AT=170.025n

.meas tran vdout0_6ck330 FIND v(dout0_6) AT=170.025n

.meas tran vdout0_7ck330 FIND v(dout0_7) AT=170.025n

.meas tran vdout0_8ck330 FIND v(dout0_8) AT=170.025n

.meas tran vdout0_9ck330 FIND v(dout0_9) AT=170.025n

.meas tran vdout0_10ck330 FIND v(dout0_10) AT=170.025n

.meas tran vdout0_11ck330 FIND v(dout0_11) AT=170.025n

.meas tran vdout0_12ck330 FIND v(dout0_12) AT=170.025n

.meas tran vdout0_13ck330 FIND v(dout0_13) AT=170.025n

.meas tran vdout0_14ck330 FIND v(dout0_14) AT=170.025n

.meas tran vdout0_15ck330 FIND v(dout0_15) AT=170.025n

.meas tran vdout0_16ck330 FIND v(dout0_16) AT=170.025n

.meas tran vdout0_17ck330 FIND v(dout0_17) AT=170.025n

.meas tran vdout0_18ck330 FIND v(dout0_18) AT=170.025n

.meas tran vdout0_19ck330 FIND v(dout0_19) AT=170.025n

.meas tran vdout0_20ck330 FIND v(dout0_20) AT=170.025n

.meas tran vdout0_21ck330 FIND v(dout0_21) AT=170.025n

.meas tran vdout0_22ck330 FIND v(dout0_22) AT=170.025n

.meas tran vdout0_23ck330 FIND v(dout0_23) AT=170.025n

.meas tran vdout0_24ck330 FIND v(dout0_24) AT=170.025n

.meas tran vdout0_25ck330 FIND v(dout0_25) AT=170.025n

.meas tran vdout0_26ck330 FIND v(dout0_26) AT=170.025n

.meas tran vdout0_27ck330 FIND v(dout0_27) AT=170.025n

.meas tran vdout0_28ck330 FIND v(dout0_28) AT=170.025n

.meas tran vdout0_29ck330 FIND v(dout0_29) AT=170.025n

.meas tran vdout0_30ck330 FIND v(dout0_30) AT=170.025n

.meas tran vdout0_31ck330 FIND v(dout0_31) AT=170.025n

.meas tran vdout0_32ck330 FIND v(dout0_32) AT=170.025n

.meas tran vdout0_33ck330 FIND v(dout0_33) AT=170.025n

.meas tran vdout0_34ck330 FIND v(dout0_34) AT=170.025n

.meas tran vdout0_35ck330 FIND v(dout0_35) AT=170.025n

.meas tran vdout0_36ck330 FIND v(dout0_36) AT=170.025n

.meas tran vdout0_37ck330 FIND v(dout0_37) AT=170.025n

.meas tran vdout0_38ck330 FIND v(dout0_38) AT=170.025n

.meas tran vdout0_39ck330 FIND v(dout0_39) AT=170.025n

.meas tran vdout0_40ck330 FIND v(dout0_40) AT=170.025n

.meas tran vdout0_41ck330 FIND v(dout0_41) AT=170.025n

.meas tran vdout0_42ck330 FIND v(dout0_42) AT=170.025n

.meas tran vdout0_43ck330 FIND v(dout0_43) AT=170.025n

.meas tran vdout0_44ck330 FIND v(dout0_44) AT=170.025n

.meas tran vdout0_45ck330 FIND v(dout0_45) AT=170.025n

.meas tran vdout0_46ck330 FIND v(dout0_46) AT=170.025n

.meas tran vdout0_47ck330 FIND v(dout0_47) AT=170.025n

.meas tran vdout0_48ck330 FIND v(dout0_48) AT=170.025n

.meas tran vdout0_49ck330 FIND v(dout0_49) AT=170.025n

.meas tran vdout0_50ck330 FIND v(dout0_50) AT=170.025n

.meas tran vdout0_51ck330 FIND v(dout0_51) AT=170.025n

.meas tran vdout0_52ck330 FIND v(dout0_52) AT=170.025n

.meas tran vdout0_53ck330 FIND v(dout0_53) AT=170.025n

.meas tran vdout0_54ck330 FIND v(dout0_54) AT=170.025n

.meas tran vdout0_55ck330 FIND v(dout0_55) AT=170.025n

.meas tran vdout0_56ck330 FIND v(dout0_56) AT=170.025n

.meas tran vdout0_57ck330 FIND v(dout0_57) AT=170.025n

.meas tran vdout0_58ck330 FIND v(dout0_58) AT=170.025n

.meas tran vdout0_59ck330 FIND v(dout0_59) AT=170.025n

.meas tran vdout0_60ck330 FIND v(dout0_60) AT=170.025n

.meas tran vdout0_61ck330 FIND v(dout0_61) AT=170.025n

.meas tran vdout0_62ck330 FIND v(dout0_62) AT=170.025n

.meas tran vdout0_63ck330 FIND v(dout0_63) AT=170.025n

.meas tran vdout0_64ck330 FIND v(dout0_64) AT=170.025n

.meas tran vdout0_65ck330 FIND v(dout0_65) AT=170.025n

.meas tran vdout0_66ck330 FIND v(dout0_66) AT=170.025n

.meas tran vdout0_67ck330 FIND v(dout0_67) AT=170.025n

.meas tran vdout0_68ck330 FIND v(dout0_68) AT=170.025n

.meas tran vdout0_69ck330 FIND v(dout0_69) AT=170.025n

.meas tran vdout0_70ck330 FIND v(dout0_70) AT=170.025n

.meas tran vdout0_71ck330 FIND v(dout0_71) AT=170.025n

.meas tran vdout0_72ck330 FIND v(dout0_72) AT=170.025n

.meas tran vdout0_73ck330 FIND v(dout0_73) AT=170.025n

.meas tran vdout0_74ck330 FIND v(dout0_74) AT=170.025n

.meas tran vdout0_75ck330 FIND v(dout0_75) AT=170.025n

.meas tran vdout0_76ck330 FIND v(dout0_76) AT=170.025n

.meas tran vdout0_77ck330 FIND v(dout0_77) AT=170.025n

.meas tran vdout0_78ck330 FIND v(dout0_78) AT=170.025n

.meas tran vdout0_79ck330 FIND v(dout0_79) AT=170.025n

.meas tran vdout0_80ck330 FIND v(dout0_80) AT=170.025n

.meas tran vdout0_81ck330 FIND v(dout0_81) AT=170.025n

.meas tran vdout0_82ck330 FIND v(dout0_82) AT=170.025n

.meas tran vdout0_83ck330 FIND v(dout0_83) AT=170.025n

.meas tran vdout0_84ck330 FIND v(dout0_84) AT=170.025n

.meas tran vdout0_85ck330 FIND v(dout0_85) AT=170.025n

.meas tran vdout0_86ck330 FIND v(dout0_86) AT=170.025n

.meas tran vdout0_87ck330 FIND v(dout0_87) AT=170.025n

.meas tran vdout0_88ck330 FIND v(dout0_88) AT=170.025n

.meas tran vdout0_89ck330 FIND v(dout0_89) AT=170.025n

.meas tran vdout0_90ck330 FIND v(dout0_90) AT=170.025n

.meas tran vdout0_91ck330 FIND v(dout0_91) AT=170.025n

.meas tran vdout0_92ck330 FIND v(dout0_92) AT=170.025n

.meas tran vdout0_93ck330 FIND v(dout0_93) AT=170.025n

.meas tran vdout0_94ck330 FIND v(dout0_94) AT=170.025n

.meas tran vdout0_95ck330 FIND v(dout0_95) AT=170.025n

.meas tran vdout0_96ck330 FIND v(dout0_96) AT=170.025n

.meas tran vdout0_97ck330 FIND v(dout0_97) AT=170.025n

.meas tran vdout0_98ck330 FIND v(dout0_98) AT=170.025n

.meas tran vdout0_99ck330 FIND v(dout0_99) AT=170.025n

.meas tran vdout0_100ck330 FIND v(dout0_100) AT=170.025n

.meas tran vdout0_101ck330 FIND v(dout0_101) AT=170.025n

.meas tran vdout0_102ck330 FIND v(dout0_102) AT=170.025n

.meas tran vdout0_103ck330 FIND v(dout0_103) AT=170.025n

.meas tran vdout0_104ck330 FIND v(dout0_104) AT=170.025n

.meas tran vdout0_105ck330 FIND v(dout0_105) AT=170.025n

.meas tran vdout0_106ck330 FIND v(dout0_106) AT=170.025n

.meas tran vdout0_107ck330 FIND v(dout0_107) AT=170.025n

.meas tran vdout0_108ck330 FIND v(dout0_108) AT=170.025n

.meas tran vdout0_109ck330 FIND v(dout0_109) AT=170.025n

.meas tran vdout0_110ck330 FIND v(dout0_110) AT=170.025n

.meas tran vdout0_111ck330 FIND v(dout0_111) AT=170.025n

.meas tran vdout0_112ck330 FIND v(dout0_112) AT=170.025n

.meas tran vdout0_113ck330 FIND v(dout0_113) AT=170.025n

.meas tran vdout0_114ck330 FIND v(dout0_114) AT=170.025n

.meas tran vdout0_115ck330 FIND v(dout0_115) AT=170.025n

.meas tran vdout0_116ck330 FIND v(dout0_116) AT=170.025n

.meas tran vdout0_117ck330 FIND v(dout0_117) AT=170.025n

.meas tran vdout0_118ck330 FIND v(dout0_118) AT=170.025n

.meas tran vdout0_119ck330 FIND v(dout0_119) AT=170.025n

.meas tran vdout0_120ck330 FIND v(dout0_120) AT=170.025n

.meas tran vdout0_121ck330 FIND v(dout0_121) AT=170.025n

.meas tran vdout0_122ck330 FIND v(dout0_122) AT=170.025n

.meas tran vdout0_123ck330 FIND v(dout0_123) AT=170.025n

.meas tran vdout0_124ck330 FIND v(dout0_124) AT=170.025n

.meas tran vdout0_125ck330 FIND v(dout0_125) AT=170.025n

.meas tran vdout0_126ck330 FIND v(dout0_126) AT=170.025n

.meas tran vdout0_127ck330 FIND v(dout0_127) AT=170.025n

.meas tran vdout0_0ck340 FIND v(dout0_0) AT=175.025n

.meas tran vdout0_1ck340 FIND v(dout0_1) AT=175.025n

.meas tran vdout0_2ck340 FIND v(dout0_2) AT=175.025n

.meas tran vdout0_3ck340 FIND v(dout0_3) AT=175.025n

.meas tran vdout0_4ck340 FIND v(dout0_4) AT=175.025n

.meas tran vdout0_5ck340 FIND v(dout0_5) AT=175.025n

.meas tran vdout0_6ck340 FIND v(dout0_6) AT=175.025n

.meas tran vdout0_7ck340 FIND v(dout0_7) AT=175.025n

.meas tran vdout0_8ck340 FIND v(dout0_8) AT=175.025n

.meas tran vdout0_9ck340 FIND v(dout0_9) AT=175.025n

.meas tran vdout0_10ck340 FIND v(dout0_10) AT=175.025n

.meas tran vdout0_11ck340 FIND v(dout0_11) AT=175.025n

.meas tran vdout0_12ck340 FIND v(dout0_12) AT=175.025n

.meas tran vdout0_13ck340 FIND v(dout0_13) AT=175.025n

.meas tran vdout0_14ck340 FIND v(dout0_14) AT=175.025n

.meas tran vdout0_15ck340 FIND v(dout0_15) AT=175.025n

.meas tran vdout0_16ck340 FIND v(dout0_16) AT=175.025n

.meas tran vdout0_17ck340 FIND v(dout0_17) AT=175.025n

.meas tran vdout0_18ck340 FIND v(dout0_18) AT=175.025n

.meas tran vdout0_19ck340 FIND v(dout0_19) AT=175.025n

.meas tran vdout0_20ck340 FIND v(dout0_20) AT=175.025n

.meas tran vdout0_21ck340 FIND v(dout0_21) AT=175.025n

.meas tran vdout0_22ck340 FIND v(dout0_22) AT=175.025n

.meas tran vdout0_23ck340 FIND v(dout0_23) AT=175.025n

.meas tran vdout0_24ck340 FIND v(dout0_24) AT=175.025n

.meas tran vdout0_25ck340 FIND v(dout0_25) AT=175.025n

.meas tran vdout0_26ck340 FIND v(dout0_26) AT=175.025n

.meas tran vdout0_27ck340 FIND v(dout0_27) AT=175.025n

.meas tran vdout0_28ck340 FIND v(dout0_28) AT=175.025n

.meas tran vdout0_29ck340 FIND v(dout0_29) AT=175.025n

.meas tran vdout0_30ck340 FIND v(dout0_30) AT=175.025n

.meas tran vdout0_31ck340 FIND v(dout0_31) AT=175.025n

.meas tran vdout0_32ck340 FIND v(dout0_32) AT=175.025n

.meas tran vdout0_33ck340 FIND v(dout0_33) AT=175.025n

.meas tran vdout0_34ck340 FIND v(dout0_34) AT=175.025n

.meas tran vdout0_35ck340 FIND v(dout0_35) AT=175.025n

.meas tran vdout0_36ck340 FIND v(dout0_36) AT=175.025n

.meas tran vdout0_37ck340 FIND v(dout0_37) AT=175.025n

.meas tran vdout0_38ck340 FIND v(dout0_38) AT=175.025n

.meas tran vdout0_39ck340 FIND v(dout0_39) AT=175.025n

.meas tran vdout0_40ck340 FIND v(dout0_40) AT=175.025n

.meas tran vdout0_41ck340 FIND v(dout0_41) AT=175.025n

.meas tran vdout0_42ck340 FIND v(dout0_42) AT=175.025n

.meas tran vdout0_43ck340 FIND v(dout0_43) AT=175.025n

.meas tran vdout0_44ck340 FIND v(dout0_44) AT=175.025n

.meas tran vdout0_45ck340 FIND v(dout0_45) AT=175.025n

.meas tran vdout0_46ck340 FIND v(dout0_46) AT=175.025n

.meas tran vdout0_47ck340 FIND v(dout0_47) AT=175.025n

.meas tran vdout0_48ck340 FIND v(dout0_48) AT=175.025n

.meas tran vdout0_49ck340 FIND v(dout0_49) AT=175.025n

.meas tran vdout0_50ck340 FIND v(dout0_50) AT=175.025n

.meas tran vdout0_51ck340 FIND v(dout0_51) AT=175.025n

.meas tran vdout0_52ck340 FIND v(dout0_52) AT=175.025n

.meas tran vdout0_53ck340 FIND v(dout0_53) AT=175.025n

.meas tran vdout0_54ck340 FIND v(dout0_54) AT=175.025n

.meas tran vdout0_55ck340 FIND v(dout0_55) AT=175.025n

.meas tran vdout0_56ck340 FIND v(dout0_56) AT=175.025n

.meas tran vdout0_57ck340 FIND v(dout0_57) AT=175.025n

.meas tran vdout0_58ck340 FIND v(dout0_58) AT=175.025n

.meas tran vdout0_59ck340 FIND v(dout0_59) AT=175.025n

.meas tran vdout0_60ck340 FIND v(dout0_60) AT=175.025n

.meas tran vdout0_61ck340 FIND v(dout0_61) AT=175.025n

.meas tran vdout0_62ck340 FIND v(dout0_62) AT=175.025n

.meas tran vdout0_63ck340 FIND v(dout0_63) AT=175.025n

.meas tran vdout0_64ck340 FIND v(dout0_64) AT=175.025n

.meas tran vdout0_65ck340 FIND v(dout0_65) AT=175.025n

.meas tran vdout0_66ck340 FIND v(dout0_66) AT=175.025n

.meas tran vdout0_67ck340 FIND v(dout0_67) AT=175.025n

.meas tran vdout0_68ck340 FIND v(dout0_68) AT=175.025n

.meas tran vdout0_69ck340 FIND v(dout0_69) AT=175.025n

.meas tran vdout0_70ck340 FIND v(dout0_70) AT=175.025n

.meas tran vdout0_71ck340 FIND v(dout0_71) AT=175.025n

.meas tran vdout0_72ck340 FIND v(dout0_72) AT=175.025n

.meas tran vdout0_73ck340 FIND v(dout0_73) AT=175.025n

.meas tran vdout0_74ck340 FIND v(dout0_74) AT=175.025n

.meas tran vdout0_75ck340 FIND v(dout0_75) AT=175.025n

.meas tran vdout0_76ck340 FIND v(dout0_76) AT=175.025n

.meas tran vdout0_77ck340 FIND v(dout0_77) AT=175.025n

.meas tran vdout0_78ck340 FIND v(dout0_78) AT=175.025n

.meas tran vdout0_79ck340 FIND v(dout0_79) AT=175.025n

.meas tran vdout0_80ck340 FIND v(dout0_80) AT=175.025n

.meas tran vdout0_81ck340 FIND v(dout0_81) AT=175.025n

.meas tran vdout0_82ck340 FIND v(dout0_82) AT=175.025n

.meas tran vdout0_83ck340 FIND v(dout0_83) AT=175.025n

.meas tran vdout0_84ck340 FIND v(dout0_84) AT=175.025n

.meas tran vdout0_85ck340 FIND v(dout0_85) AT=175.025n

.meas tran vdout0_86ck340 FIND v(dout0_86) AT=175.025n

.meas tran vdout0_87ck340 FIND v(dout0_87) AT=175.025n

.meas tran vdout0_88ck340 FIND v(dout0_88) AT=175.025n

.meas tran vdout0_89ck340 FIND v(dout0_89) AT=175.025n

.meas tran vdout0_90ck340 FIND v(dout0_90) AT=175.025n

.meas tran vdout0_91ck340 FIND v(dout0_91) AT=175.025n

.meas tran vdout0_92ck340 FIND v(dout0_92) AT=175.025n

.meas tran vdout0_93ck340 FIND v(dout0_93) AT=175.025n

.meas tran vdout0_94ck340 FIND v(dout0_94) AT=175.025n

.meas tran vdout0_95ck340 FIND v(dout0_95) AT=175.025n

.meas tran vdout0_96ck340 FIND v(dout0_96) AT=175.025n

.meas tran vdout0_97ck340 FIND v(dout0_97) AT=175.025n

.meas tran vdout0_98ck340 FIND v(dout0_98) AT=175.025n

.meas tran vdout0_99ck340 FIND v(dout0_99) AT=175.025n

.meas tran vdout0_100ck340 FIND v(dout0_100) AT=175.025n

.meas tran vdout0_101ck340 FIND v(dout0_101) AT=175.025n

.meas tran vdout0_102ck340 FIND v(dout0_102) AT=175.025n

.meas tran vdout0_103ck340 FIND v(dout0_103) AT=175.025n

.meas tran vdout0_104ck340 FIND v(dout0_104) AT=175.025n

.meas tran vdout0_105ck340 FIND v(dout0_105) AT=175.025n

.meas tran vdout0_106ck340 FIND v(dout0_106) AT=175.025n

.meas tran vdout0_107ck340 FIND v(dout0_107) AT=175.025n

.meas tran vdout0_108ck340 FIND v(dout0_108) AT=175.025n

.meas tran vdout0_109ck340 FIND v(dout0_109) AT=175.025n

.meas tran vdout0_110ck340 FIND v(dout0_110) AT=175.025n

.meas tran vdout0_111ck340 FIND v(dout0_111) AT=175.025n

.meas tran vdout0_112ck340 FIND v(dout0_112) AT=175.025n

.meas tran vdout0_113ck340 FIND v(dout0_113) AT=175.025n

.meas tran vdout0_114ck340 FIND v(dout0_114) AT=175.025n

.meas tran vdout0_115ck340 FIND v(dout0_115) AT=175.025n

.meas tran vdout0_116ck340 FIND v(dout0_116) AT=175.025n

.meas tran vdout0_117ck340 FIND v(dout0_117) AT=175.025n

.meas tran vdout0_118ck340 FIND v(dout0_118) AT=175.025n

.meas tran vdout0_119ck340 FIND v(dout0_119) AT=175.025n

.meas tran vdout0_120ck340 FIND v(dout0_120) AT=175.025n

.meas tran vdout0_121ck340 FIND v(dout0_121) AT=175.025n

.meas tran vdout0_122ck340 FIND v(dout0_122) AT=175.025n

.meas tran vdout0_123ck340 FIND v(dout0_123) AT=175.025n

.meas tran vdout0_124ck340 FIND v(dout0_124) AT=175.025n

.meas tran vdout0_125ck340 FIND v(dout0_125) AT=175.025n

.meas tran vdout0_126ck340 FIND v(dout0_126) AT=175.025n

.meas tran vdout0_127ck340 FIND v(dout0_127) AT=175.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_0ck460 FIND v(dout0_0) AT=235.025n

.meas tran vdout0_1ck460 FIND v(dout0_1) AT=235.025n

.meas tran vdout0_2ck460 FIND v(dout0_2) AT=235.025n

.meas tran vdout0_3ck460 FIND v(dout0_3) AT=235.025n

.meas tran vdout0_4ck460 FIND v(dout0_4) AT=235.025n

.meas tran vdout0_5ck460 FIND v(dout0_5) AT=235.025n

.meas tran vdout0_6ck460 FIND v(dout0_6) AT=235.025n

.meas tran vdout0_7ck460 FIND v(dout0_7) AT=235.025n

.meas tran vdout0_8ck460 FIND v(dout0_8) AT=235.025n

.meas tran vdout0_9ck460 FIND v(dout0_9) AT=235.025n

.meas tran vdout0_10ck460 FIND v(dout0_10) AT=235.025n

.meas tran vdout0_11ck460 FIND v(dout0_11) AT=235.025n

.meas tran vdout0_12ck460 FIND v(dout0_12) AT=235.025n

.meas tran vdout0_13ck460 FIND v(dout0_13) AT=235.025n

.meas tran vdout0_14ck460 FIND v(dout0_14) AT=235.025n

.meas tran vdout0_15ck460 FIND v(dout0_15) AT=235.025n

.meas tran vdout0_16ck460 FIND v(dout0_16) AT=235.025n

.meas tran vdout0_17ck460 FIND v(dout0_17) AT=235.025n

.meas tran vdout0_18ck460 FIND v(dout0_18) AT=235.025n

.meas tran vdout0_19ck460 FIND v(dout0_19) AT=235.025n

.meas tran vdout0_20ck460 FIND v(dout0_20) AT=235.025n

.meas tran vdout0_21ck460 FIND v(dout0_21) AT=235.025n

.meas tran vdout0_22ck460 FIND v(dout0_22) AT=235.025n

.meas tran vdout0_23ck460 FIND v(dout0_23) AT=235.025n

.meas tran vdout0_24ck460 FIND v(dout0_24) AT=235.025n

.meas tran vdout0_25ck460 FIND v(dout0_25) AT=235.025n

.meas tran vdout0_26ck460 FIND v(dout0_26) AT=235.025n

.meas tran vdout0_27ck460 FIND v(dout0_27) AT=235.025n

.meas tran vdout0_28ck460 FIND v(dout0_28) AT=235.025n

.meas tran vdout0_29ck460 FIND v(dout0_29) AT=235.025n

.meas tran vdout0_30ck460 FIND v(dout0_30) AT=235.025n

.meas tran vdout0_31ck460 FIND v(dout0_31) AT=235.025n

.meas tran vdout0_32ck460 FIND v(dout0_32) AT=235.025n

.meas tran vdout0_33ck460 FIND v(dout0_33) AT=235.025n

.meas tran vdout0_34ck460 FIND v(dout0_34) AT=235.025n

.meas tran vdout0_35ck460 FIND v(dout0_35) AT=235.025n

.meas tran vdout0_36ck460 FIND v(dout0_36) AT=235.025n

.meas tran vdout0_37ck460 FIND v(dout0_37) AT=235.025n

.meas tran vdout0_38ck460 FIND v(dout0_38) AT=235.025n

.meas tran vdout0_39ck460 FIND v(dout0_39) AT=235.025n

.meas tran vdout0_40ck460 FIND v(dout0_40) AT=235.025n

.meas tran vdout0_41ck460 FIND v(dout0_41) AT=235.025n

.meas tran vdout0_42ck460 FIND v(dout0_42) AT=235.025n

.meas tran vdout0_43ck460 FIND v(dout0_43) AT=235.025n

.meas tran vdout0_44ck460 FIND v(dout0_44) AT=235.025n

.meas tran vdout0_45ck460 FIND v(dout0_45) AT=235.025n

.meas tran vdout0_46ck460 FIND v(dout0_46) AT=235.025n

.meas tran vdout0_47ck460 FIND v(dout0_47) AT=235.025n

.meas tran vdout0_48ck460 FIND v(dout0_48) AT=235.025n

.meas tran vdout0_49ck460 FIND v(dout0_49) AT=235.025n

.meas tran vdout0_50ck460 FIND v(dout0_50) AT=235.025n

.meas tran vdout0_51ck460 FIND v(dout0_51) AT=235.025n

.meas tran vdout0_52ck460 FIND v(dout0_52) AT=235.025n

.meas tran vdout0_53ck460 FIND v(dout0_53) AT=235.025n

.meas tran vdout0_54ck460 FIND v(dout0_54) AT=235.025n

.meas tran vdout0_55ck460 FIND v(dout0_55) AT=235.025n

.meas tran vdout0_56ck460 FIND v(dout0_56) AT=235.025n

.meas tran vdout0_57ck460 FIND v(dout0_57) AT=235.025n

.meas tran vdout0_58ck460 FIND v(dout0_58) AT=235.025n

.meas tran vdout0_59ck460 FIND v(dout0_59) AT=235.025n

.meas tran vdout0_60ck460 FIND v(dout0_60) AT=235.025n

.meas tran vdout0_61ck460 FIND v(dout0_61) AT=235.025n

.meas tran vdout0_62ck460 FIND v(dout0_62) AT=235.025n

.meas tran vdout0_63ck460 FIND v(dout0_63) AT=235.025n

.meas tran vdout0_64ck460 FIND v(dout0_64) AT=235.025n

.meas tran vdout0_65ck460 FIND v(dout0_65) AT=235.025n

.meas tran vdout0_66ck460 FIND v(dout0_66) AT=235.025n

.meas tran vdout0_67ck460 FIND v(dout0_67) AT=235.025n

.meas tran vdout0_68ck460 FIND v(dout0_68) AT=235.025n

.meas tran vdout0_69ck460 FIND v(dout0_69) AT=235.025n

.meas tran vdout0_70ck460 FIND v(dout0_70) AT=235.025n

.meas tran vdout0_71ck460 FIND v(dout0_71) AT=235.025n

.meas tran vdout0_72ck460 FIND v(dout0_72) AT=235.025n

.meas tran vdout0_73ck460 FIND v(dout0_73) AT=235.025n

.meas tran vdout0_74ck460 FIND v(dout0_74) AT=235.025n

.meas tran vdout0_75ck460 FIND v(dout0_75) AT=235.025n

.meas tran vdout0_76ck460 FIND v(dout0_76) AT=235.025n

.meas tran vdout0_77ck460 FIND v(dout0_77) AT=235.025n

.meas tran vdout0_78ck460 FIND v(dout0_78) AT=235.025n

.meas tran vdout0_79ck460 FIND v(dout0_79) AT=235.025n

.meas tran vdout0_80ck460 FIND v(dout0_80) AT=235.025n

.meas tran vdout0_81ck460 FIND v(dout0_81) AT=235.025n

.meas tran vdout0_82ck460 FIND v(dout0_82) AT=235.025n

.meas tran vdout0_83ck460 FIND v(dout0_83) AT=235.025n

.meas tran vdout0_84ck460 FIND v(dout0_84) AT=235.025n

.meas tran vdout0_85ck460 FIND v(dout0_85) AT=235.025n

.meas tran vdout0_86ck460 FIND v(dout0_86) AT=235.025n

.meas tran vdout0_87ck460 FIND v(dout0_87) AT=235.025n

.meas tran vdout0_88ck460 FIND v(dout0_88) AT=235.025n

.meas tran vdout0_89ck460 FIND v(dout0_89) AT=235.025n

.meas tran vdout0_90ck460 FIND v(dout0_90) AT=235.025n

.meas tran vdout0_91ck460 FIND v(dout0_91) AT=235.025n

.meas tran vdout0_92ck460 FIND v(dout0_92) AT=235.025n

.meas tran vdout0_93ck460 FIND v(dout0_93) AT=235.025n

.meas tran vdout0_94ck460 FIND v(dout0_94) AT=235.025n

.meas tran vdout0_95ck460 FIND v(dout0_95) AT=235.025n

.meas tran vdout0_96ck460 FIND v(dout0_96) AT=235.025n

.meas tran vdout0_97ck460 FIND v(dout0_97) AT=235.025n

.meas tran vdout0_98ck460 FIND v(dout0_98) AT=235.025n

.meas tran vdout0_99ck460 FIND v(dout0_99) AT=235.025n

.meas tran vdout0_100ck460 FIND v(dout0_100) AT=235.025n

.meas tran vdout0_101ck460 FIND v(dout0_101) AT=235.025n

.meas tran vdout0_102ck460 FIND v(dout0_102) AT=235.025n

.meas tran vdout0_103ck460 FIND v(dout0_103) AT=235.025n

.meas tran vdout0_104ck460 FIND v(dout0_104) AT=235.025n

.meas tran vdout0_105ck460 FIND v(dout0_105) AT=235.025n

.meas tran vdout0_106ck460 FIND v(dout0_106) AT=235.025n

.meas tran vdout0_107ck460 FIND v(dout0_107) AT=235.025n

.meas tran vdout0_108ck460 FIND v(dout0_108) AT=235.025n

.meas tran vdout0_109ck460 FIND v(dout0_109) AT=235.025n

.meas tran vdout0_110ck460 FIND v(dout0_110) AT=235.025n

.meas tran vdout0_111ck460 FIND v(dout0_111) AT=235.025n

.meas tran vdout0_112ck460 FIND v(dout0_112) AT=235.025n

.meas tran vdout0_113ck460 FIND v(dout0_113) AT=235.025n

.meas tran vdout0_114ck460 FIND v(dout0_114) AT=235.025n

.meas tran vdout0_115ck460 FIND v(dout0_115) AT=235.025n

.meas tran vdout0_116ck460 FIND v(dout0_116) AT=235.025n

.meas tran vdout0_117ck460 FIND v(dout0_117) AT=235.025n

.meas tran vdout0_118ck460 FIND v(dout0_118) AT=235.025n

.meas tran vdout0_119ck460 FIND v(dout0_119) AT=235.025n

.meas tran vdout0_120ck460 FIND v(dout0_120) AT=235.025n

.meas tran vdout0_121ck460 FIND v(dout0_121) AT=235.025n

.meas tran vdout0_122ck460 FIND v(dout0_122) AT=235.025n

.meas tran vdout0_123ck460 FIND v(dout0_123) AT=235.025n

.meas tran vdout0_124ck460 FIND v(dout0_124) AT=235.025n

.meas tran vdout0_125ck460 FIND v(dout0_125) AT=235.025n

.meas tran vdout0_126ck460 FIND v(dout0_126) AT=235.025n

.meas tran vdout0_127ck460 FIND v(dout0_127) AT=235.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_0ck530 FIND v(dout0_0) AT=270.025n

.meas tran vdout0_1ck530 FIND v(dout0_1) AT=270.025n

.meas tran vdout0_2ck530 FIND v(dout0_2) AT=270.025n

.meas tran vdout0_3ck530 FIND v(dout0_3) AT=270.025n

.meas tran vdout0_4ck530 FIND v(dout0_4) AT=270.025n

.meas tran vdout0_5ck530 FIND v(dout0_5) AT=270.025n

.meas tran vdout0_6ck530 FIND v(dout0_6) AT=270.025n

.meas tran vdout0_7ck530 FIND v(dout0_7) AT=270.025n

.meas tran vdout0_8ck530 FIND v(dout0_8) AT=270.025n

.meas tran vdout0_9ck530 FIND v(dout0_9) AT=270.025n

.meas tran vdout0_10ck530 FIND v(dout0_10) AT=270.025n

.meas tran vdout0_11ck530 FIND v(dout0_11) AT=270.025n

.meas tran vdout0_12ck530 FIND v(dout0_12) AT=270.025n

.meas tran vdout0_13ck530 FIND v(dout0_13) AT=270.025n

.meas tran vdout0_14ck530 FIND v(dout0_14) AT=270.025n

.meas tran vdout0_15ck530 FIND v(dout0_15) AT=270.025n

.meas tran vdout0_16ck530 FIND v(dout0_16) AT=270.025n

.meas tran vdout0_17ck530 FIND v(dout0_17) AT=270.025n

.meas tran vdout0_18ck530 FIND v(dout0_18) AT=270.025n

.meas tran vdout0_19ck530 FIND v(dout0_19) AT=270.025n

.meas tran vdout0_20ck530 FIND v(dout0_20) AT=270.025n

.meas tran vdout0_21ck530 FIND v(dout0_21) AT=270.025n

.meas tran vdout0_22ck530 FIND v(dout0_22) AT=270.025n

.meas tran vdout0_23ck530 FIND v(dout0_23) AT=270.025n

.meas tran vdout0_24ck530 FIND v(dout0_24) AT=270.025n

.meas tran vdout0_25ck530 FIND v(dout0_25) AT=270.025n

.meas tran vdout0_26ck530 FIND v(dout0_26) AT=270.025n

.meas tran vdout0_27ck530 FIND v(dout0_27) AT=270.025n

.meas tran vdout0_28ck530 FIND v(dout0_28) AT=270.025n

.meas tran vdout0_29ck530 FIND v(dout0_29) AT=270.025n

.meas tran vdout0_30ck530 FIND v(dout0_30) AT=270.025n

.meas tran vdout0_31ck530 FIND v(dout0_31) AT=270.025n

.meas tran vdout0_32ck530 FIND v(dout0_32) AT=270.025n

.meas tran vdout0_33ck530 FIND v(dout0_33) AT=270.025n

.meas tran vdout0_34ck530 FIND v(dout0_34) AT=270.025n

.meas tran vdout0_35ck530 FIND v(dout0_35) AT=270.025n

.meas tran vdout0_36ck530 FIND v(dout0_36) AT=270.025n

.meas tran vdout0_37ck530 FIND v(dout0_37) AT=270.025n

.meas tran vdout0_38ck530 FIND v(dout0_38) AT=270.025n

.meas tran vdout0_39ck530 FIND v(dout0_39) AT=270.025n

.meas tran vdout0_40ck530 FIND v(dout0_40) AT=270.025n

.meas tran vdout0_41ck530 FIND v(dout0_41) AT=270.025n

.meas tran vdout0_42ck530 FIND v(dout0_42) AT=270.025n

.meas tran vdout0_43ck530 FIND v(dout0_43) AT=270.025n

.meas tran vdout0_44ck530 FIND v(dout0_44) AT=270.025n

.meas tran vdout0_45ck530 FIND v(dout0_45) AT=270.025n

.meas tran vdout0_46ck530 FIND v(dout0_46) AT=270.025n

.meas tran vdout0_47ck530 FIND v(dout0_47) AT=270.025n

.meas tran vdout0_48ck530 FIND v(dout0_48) AT=270.025n

.meas tran vdout0_49ck530 FIND v(dout0_49) AT=270.025n

.meas tran vdout0_50ck530 FIND v(dout0_50) AT=270.025n

.meas tran vdout0_51ck530 FIND v(dout0_51) AT=270.025n

.meas tran vdout0_52ck530 FIND v(dout0_52) AT=270.025n

.meas tran vdout0_53ck530 FIND v(dout0_53) AT=270.025n

.meas tran vdout0_54ck530 FIND v(dout0_54) AT=270.025n

.meas tran vdout0_55ck530 FIND v(dout0_55) AT=270.025n

.meas tran vdout0_56ck530 FIND v(dout0_56) AT=270.025n

.meas tran vdout0_57ck530 FIND v(dout0_57) AT=270.025n

.meas tran vdout0_58ck530 FIND v(dout0_58) AT=270.025n

.meas tran vdout0_59ck530 FIND v(dout0_59) AT=270.025n

.meas tran vdout0_60ck530 FIND v(dout0_60) AT=270.025n

.meas tran vdout0_61ck530 FIND v(dout0_61) AT=270.025n

.meas tran vdout0_62ck530 FIND v(dout0_62) AT=270.025n

.meas tran vdout0_63ck530 FIND v(dout0_63) AT=270.025n

.meas tran vdout0_64ck530 FIND v(dout0_64) AT=270.025n

.meas tran vdout0_65ck530 FIND v(dout0_65) AT=270.025n

.meas tran vdout0_66ck530 FIND v(dout0_66) AT=270.025n

.meas tran vdout0_67ck530 FIND v(dout0_67) AT=270.025n

.meas tran vdout0_68ck530 FIND v(dout0_68) AT=270.025n

.meas tran vdout0_69ck530 FIND v(dout0_69) AT=270.025n

.meas tran vdout0_70ck530 FIND v(dout0_70) AT=270.025n

.meas tran vdout0_71ck530 FIND v(dout0_71) AT=270.025n

.meas tran vdout0_72ck530 FIND v(dout0_72) AT=270.025n

.meas tran vdout0_73ck530 FIND v(dout0_73) AT=270.025n

.meas tran vdout0_74ck530 FIND v(dout0_74) AT=270.025n

.meas tran vdout0_75ck530 FIND v(dout0_75) AT=270.025n

.meas tran vdout0_76ck530 FIND v(dout0_76) AT=270.025n

.meas tran vdout0_77ck530 FIND v(dout0_77) AT=270.025n

.meas tran vdout0_78ck530 FIND v(dout0_78) AT=270.025n

.meas tran vdout0_79ck530 FIND v(dout0_79) AT=270.025n

.meas tran vdout0_80ck530 FIND v(dout0_80) AT=270.025n

.meas tran vdout0_81ck530 FIND v(dout0_81) AT=270.025n

.meas tran vdout0_82ck530 FIND v(dout0_82) AT=270.025n

.meas tran vdout0_83ck530 FIND v(dout0_83) AT=270.025n

.meas tran vdout0_84ck530 FIND v(dout0_84) AT=270.025n

.meas tran vdout0_85ck530 FIND v(dout0_85) AT=270.025n

.meas tran vdout0_86ck530 FIND v(dout0_86) AT=270.025n

.meas tran vdout0_87ck530 FIND v(dout0_87) AT=270.025n

.meas tran vdout0_88ck530 FIND v(dout0_88) AT=270.025n

.meas tran vdout0_89ck530 FIND v(dout0_89) AT=270.025n

.meas tran vdout0_90ck530 FIND v(dout0_90) AT=270.025n

.meas tran vdout0_91ck530 FIND v(dout0_91) AT=270.025n

.meas tran vdout0_92ck530 FIND v(dout0_92) AT=270.025n

.meas tran vdout0_93ck530 FIND v(dout0_93) AT=270.025n

.meas tran vdout0_94ck530 FIND v(dout0_94) AT=270.025n

.meas tran vdout0_95ck530 FIND v(dout0_95) AT=270.025n

.meas tran vdout0_96ck530 FIND v(dout0_96) AT=270.025n

.meas tran vdout0_97ck530 FIND v(dout0_97) AT=270.025n

.meas tran vdout0_98ck530 FIND v(dout0_98) AT=270.025n

.meas tran vdout0_99ck530 FIND v(dout0_99) AT=270.025n

.meas tran vdout0_100ck530 FIND v(dout0_100) AT=270.025n

.meas tran vdout0_101ck530 FIND v(dout0_101) AT=270.025n

.meas tran vdout0_102ck530 FIND v(dout0_102) AT=270.025n

.meas tran vdout0_103ck530 FIND v(dout0_103) AT=270.025n

.meas tran vdout0_104ck530 FIND v(dout0_104) AT=270.025n

.meas tran vdout0_105ck530 FIND v(dout0_105) AT=270.025n

.meas tran vdout0_106ck530 FIND v(dout0_106) AT=270.025n

.meas tran vdout0_107ck530 FIND v(dout0_107) AT=270.025n

.meas tran vdout0_108ck530 FIND v(dout0_108) AT=270.025n

.meas tran vdout0_109ck530 FIND v(dout0_109) AT=270.025n

.meas tran vdout0_110ck530 FIND v(dout0_110) AT=270.025n

.meas tran vdout0_111ck530 FIND v(dout0_111) AT=270.025n

.meas tran vdout0_112ck530 FIND v(dout0_112) AT=270.025n

.meas tran vdout0_113ck530 FIND v(dout0_113) AT=270.025n

.meas tran vdout0_114ck530 FIND v(dout0_114) AT=270.025n

.meas tran vdout0_115ck530 FIND v(dout0_115) AT=270.025n

.meas tran vdout0_116ck530 FIND v(dout0_116) AT=270.025n

.meas tran vdout0_117ck530 FIND v(dout0_117) AT=270.025n

.meas tran vdout0_118ck530 FIND v(dout0_118) AT=270.025n

.meas tran vdout0_119ck530 FIND v(dout0_119) AT=270.025n

.meas tran vdout0_120ck530 FIND v(dout0_120) AT=270.025n

.meas tran vdout0_121ck530 FIND v(dout0_121) AT=270.025n

.meas tran vdout0_122ck530 FIND v(dout0_122) AT=270.025n

.meas tran vdout0_123ck530 FIND v(dout0_123) AT=270.025n

.meas tran vdout0_124ck530 FIND v(dout0_124) AT=270.025n

.meas tran vdout0_125ck530 FIND v(dout0_125) AT=270.025n

.meas tran vdout0_126ck530 FIND v(dout0_126) AT=270.025n

.meas tran vdout0_127ck530 FIND v(dout0_127) AT=270.025n

.meas tran vdout0_0ck550 FIND v(dout0_0) AT=280.025n

.meas tran vdout0_1ck550 FIND v(dout0_1) AT=280.025n

.meas tran vdout0_2ck550 FIND v(dout0_2) AT=280.025n

.meas tran vdout0_3ck550 FIND v(dout0_3) AT=280.025n

.meas tran vdout0_4ck550 FIND v(dout0_4) AT=280.025n

.meas tran vdout0_5ck550 FIND v(dout0_5) AT=280.025n

.meas tran vdout0_6ck550 FIND v(dout0_6) AT=280.025n

.meas tran vdout0_7ck550 FIND v(dout0_7) AT=280.025n

.meas tran vdout0_8ck550 FIND v(dout0_8) AT=280.025n

.meas tran vdout0_9ck550 FIND v(dout0_9) AT=280.025n

.meas tran vdout0_10ck550 FIND v(dout0_10) AT=280.025n

.meas tran vdout0_11ck550 FIND v(dout0_11) AT=280.025n

.meas tran vdout0_12ck550 FIND v(dout0_12) AT=280.025n

.meas tran vdout0_13ck550 FIND v(dout0_13) AT=280.025n

.meas tran vdout0_14ck550 FIND v(dout0_14) AT=280.025n

.meas tran vdout0_15ck550 FIND v(dout0_15) AT=280.025n

.meas tran vdout0_16ck550 FIND v(dout0_16) AT=280.025n

.meas tran vdout0_17ck550 FIND v(dout0_17) AT=280.025n

.meas tran vdout0_18ck550 FIND v(dout0_18) AT=280.025n

.meas tran vdout0_19ck550 FIND v(dout0_19) AT=280.025n

.meas tran vdout0_20ck550 FIND v(dout0_20) AT=280.025n

.meas tran vdout0_21ck550 FIND v(dout0_21) AT=280.025n

.meas tran vdout0_22ck550 FIND v(dout0_22) AT=280.025n

.meas tran vdout0_23ck550 FIND v(dout0_23) AT=280.025n

.meas tran vdout0_24ck550 FIND v(dout0_24) AT=280.025n

.meas tran vdout0_25ck550 FIND v(dout0_25) AT=280.025n

.meas tran vdout0_26ck550 FIND v(dout0_26) AT=280.025n

.meas tran vdout0_27ck550 FIND v(dout0_27) AT=280.025n

.meas tran vdout0_28ck550 FIND v(dout0_28) AT=280.025n

.meas tran vdout0_29ck550 FIND v(dout0_29) AT=280.025n

.meas tran vdout0_30ck550 FIND v(dout0_30) AT=280.025n

.meas tran vdout0_31ck550 FIND v(dout0_31) AT=280.025n

.meas tran vdout0_32ck550 FIND v(dout0_32) AT=280.025n

.meas tran vdout0_33ck550 FIND v(dout0_33) AT=280.025n

.meas tran vdout0_34ck550 FIND v(dout0_34) AT=280.025n

.meas tran vdout0_35ck550 FIND v(dout0_35) AT=280.025n

.meas tran vdout0_36ck550 FIND v(dout0_36) AT=280.025n

.meas tran vdout0_37ck550 FIND v(dout0_37) AT=280.025n

.meas tran vdout0_38ck550 FIND v(dout0_38) AT=280.025n

.meas tran vdout0_39ck550 FIND v(dout0_39) AT=280.025n

.meas tran vdout0_40ck550 FIND v(dout0_40) AT=280.025n

.meas tran vdout0_41ck550 FIND v(dout0_41) AT=280.025n

.meas tran vdout0_42ck550 FIND v(dout0_42) AT=280.025n

.meas tran vdout0_43ck550 FIND v(dout0_43) AT=280.025n

.meas tran vdout0_44ck550 FIND v(dout0_44) AT=280.025n

.meas tran vdout0_45ck550 FIND v(dout0_45) AT=280.025n

.meas tran vdout0_46ck550 FIND v(dout0_46) AT=280.025n

.meas tran vdout0_47ck550 FIND v(dout0_47) AT=280.025n

.meas tran vdout0_48ck550 FIND v(dout0_48) AT=280.025n

.meas tran vdout0_49ck550 FIND v(dout0_49) AT=280.025n

.meas tran vdout0_50ck550 FIND v(dout0_50) AT=280.025n

.meas tran vdout0_51ck550 FIND v(dout0_51) AT=280.025n

.meas tran vdout0_52ck550 FIND v(dout0_52) AT=280.025n

.meas tran vdout0_53ck550 FIND v(dout0_53) AT=280.025n

.meas tran vdout0_54ck550 FIND v(dout0_54) AT=280.025n

.meas tran vdout0_55ck550 FIND v(dout0_55) AT=280.025n

.meas tran vdout0_56ck550 FIND v(dout0_56) AT=280.025n

.meas tran vdout0_57ck550 FIND v(dout0_57) AT=280.025n

.meas tran vdout0_58ck550 FIND v(dout0_58) AT=280.025n

.meas tran vdout0_59ck550 FIND v(dout0_59) AT=280.025n

.meas tran vdout0_60ck550 FIND v(dout0_60) AT=280.025n

.meas tran vdout0_61ck550 FIND v(dout0_61) AT=280.025n

.meas tran vdout0_62ck550 FIND v(dout0_62) AT=280.025n

.meas tran vdout0_63ck550 FIND v(dout0_63) AT=280.025n

.meas tran vdout0_64ck550 FIND v(dout0_64) AT=280.025n

.meas tran vdout0_65ck550 FIND v(dout0_65) AT=280.025n

.meas tran vdout0_66ck550 FIND v(dout0_66) AT=280.025n

.meas tran vdout0_67ck550 FIND v(dout0_67) AT=280.025n

.meas tran vdout0_68ck550 FIND v(dout0_68) AT=280.025n

.meas tran vdout0_69ck550 FIND v(dout0_69) AT=280.025n

.meas tran vdout0_70ck550 FIND v(dout0_70) AT=280.025n

.meas tran vdout0_71ck550 FIND v(dout0_71) AT=280.025n

.meas tran vdout0_72ck550 FIND v(dout0_72) AT=280.025n

.meas tran vdout0_73ck550 FIND v(dout0_73) AT=280.025n

.meas tran vdout0_74ck550 FIND v(dout0_74) AT=280.025n

.meas tran vdout0_75ck550 FIND v(dout0_75) AT=280.025n

.meas tran vdout0_76ck550 FIND v(dout0_76) AT=280.025n

.meas tran vdout0_77ck550 FIND v(dout0_77) AT=280.025n

.meas tran vdout0_78ck550 FIND v(dout0_78) AT=280.025n

.meas tran vdout0_79ck550 FIND v(dout0_79) AT=280.025n

.meas tran vdout0_80ck550 FIND v(dout0_80) AT=280.025n

.meas tran vdout0_81ck550 FIND v(dout0_81) AT=280.025n

.meas tran vdout0_82ck550 FIND v(dout0_82) AT=280.025n

.meas tran vdout0_83ck550 FIND v(dout0_83) AT=280.025n

.meas tran vdout0_84ck550 FIND v(dout0_84) AT=280.025n

.meas tran vdout0_85ck550 FIND v(dout0_85) AT=280.025n

.meas tran vdout0_86ck550 FIND v(dout0_86) AT=280.025n

.meas tran vdout0_87ck550 FIND v(dout0_87) AT=280.025n

.meas tran vdout0_88ck550 FIND v(dout0_88) AT=280.025n

.meas tran vdout0_89ck550 FIND v(dout0_89) AT=280.025n

.meas tran vdout0_90ck550 FIND v(dout0_90) AT=280.025n

.meas tran vdout0_91ck550 FIND v(dout0_91) AT=280.025n

.meas tran vdout0_92ck550 FIND v(dout0_92) AT=280.025n

.meas tran vdout0_93ck550 FIND v(dout0_93) AT=280.025n

.meas tran vdout0_94ck550 FIND v(dout0_94) AT=280.025n

.meas tran vdout0_95ck550 FIND v(dout0_95) AT=280.025n

.meas tran vdout0_96ck550 FIND v(dout0_96) AT=280.025n

.meas tran vdout0_97ck550 FIND v(dout0_97) AT=280.025n

.meas tran vdout0_98ck550 FIND v(dout0_98) AT=280.025n

.meas tran vdout0_99ck550 FIND v(dout0_99) AT=280.025n

.meas tran vdout0_100ck550 FIND v(dout0_100) AT=280.025n

.meas tran vdout0_101ck550 FIND v(dout0_101) AT=280.025n

.meas tran vdout0_102ck550 FIND v(dout0_102) AT=280.025n

.meas tran vdout0_103ck550 FIND v(dout0_103) AT=280.025n

.meas tran vdout0_104ck550 FIND v(dout0_104) AT=280.025n

.meas tran vdout0_105ck550 FIND v(dout0_105) AT=280.025n

.meas tran vdout0_106ck550 FIND v(dout0_106) AT=280.025n

.meas tran vdout0_107ck550 FIND v(dout0_107) AT=280.025n

.meas tran vdout0_108ck550 FIND v(dout0_108) AT=280.025n

.meas tran vdout0_109ck550 FIND v(dout0_109) AT=280.025n

.meas tran vdout0_110ck550 FIND v(dout0_110) AT=280.025n

.meas tran vdout0_111ck550 FIND v(dout0_111) AT=280.025n

.meas tran vdout0_112ck550 FIND v(dout0_112) AT=280.025n

.meas tran vdout0_113ck550 FIND v(dout0_113) AT=280.025n

.meas tran vdout0_114ck550 FIND v(dout0_114) AT=280.025n

.meas tran vdout0_115ck550 FIND v(dout0_115) AT=280.025n

.meas tran vdout0_116ck550 FIND v(dout0_116) AT=280.025n

.meas tran vdout0_117ck550 FIND v(dout0_117) AT=280.025n

.meas tran vdout0_118ck550 FIND v(dout0_118) AT=280.025n

.meas tran vdout0_119ck550 FIND v(dout0_119) AT=280.025n

.meas tran vdout0_120ck550 FIND v(dout0_120) AT=280.025n

.meas tran vdout0_121ck550 FIND v(dout0_121) AT=280.025n

.meas tran vdout0_122ck550 FIND v(dout0_122) AT=280.025n

.meas tran vdout0_123ck550 FIND v(dout0_123) AT=280.025n

.meas tran vdout0_124ck550 FIND v(dout0_124) AT=280.025n

.meas tran vdout0_125ck550 FIND v(dout0_125) AT=280.025n

.meas tran vdout0_126ck550 FIND v(dout0_126) AT=280.025n

.meas tran vdout0_127ck550 FIND v(dout0_127) AT=280.025n

.meas tran vdout0_0ck590 FIND v(dout0_0) AT=300.025n

.meas tran vdout0_1ck590 FIND v(dout0_1) AT=300.025n

.meas tran vdout0_2ck590 FIND v(dout0_2) AT=300.025n

.meas tran vdout0_3ck590 FIND v(dout0_3) AT=300.025n

.meas tran vdout0_4ck590 FIND v(dout0_4) AT=300.025n

.meas tran vdout0_5ck590 FIND v(dout0_5) AT=300.025n

.meas tran vdout0_6ck590 FIND v(dout0_6) AT=300.025n

.meas tran vdout0_7ck590 FIND v(dout0_7) AT=300.025n

.meas tran vdout0_8ck590 FIND v(dout0_8) AT=300.025n

.meas tran vdout0_9ck590 FIND v(dout0_9) AT=300.025n

.meas tran vdout0_10ck590 FIND v(dout0_10) AT=300.025n

.meas tran vdout0_11ck590 FIND v(dout0_11) AT=300.025n

.meas tran vdout0_12ck590 FIND v(dout0_12) AT=300.025n

.meas tran vdout0_13ck590 FIND v(dout0_13) AT=300.025n

.meas tran vdout0_14ck590 FIND v(dout0_14) AT=300.025n

.meas tran vdout0_15ck590 FIND v(dout0_15) AT=300.025n

.meas tran vdout0_16ck590 FIND v(dout0_16) AT=300.025n

.meas tran vdout0_17ck590 FIND v(dout0_17) AT=300.025n

.meas tran vdout0_18ck590 FIND v(dout0_18) AT=300.025n

.meas tran vdout0_19ck590 FIND v(dout0_19) AT=300.025n

.meas tran vdout0_20ck590 FIND v(dout0_20) AT=300.025n

.meas tran vdout0_21ck590 FIND v(dout0_21) AT=300.025n

.meas tran vdout0_22ck590 FIND v(dout0_22) AT=300.025n

.meas tran vdout0_23ck590 FIND v(dout0_23) AT=300.025n

.meas tran vdout0_24ck590 FIND v(dout0_24) AT=300.025n

.meas tran vdout0_25ck590 FIND v(dout0_25) AT=300.025n

.meas tran vdout0_26ck590 FIND v(dout0_26) AT=300.025n

.meas tran vdout0_27ck590 FIND v(dout0_27) AT=300.025n

.meas tran vdout0_28ck590 FIND v(dout0_28) AT=300.025n

.meas tran vdout0_29ck590 FIND v(dout0_29) AT=300.025n

.meas tran vdout0_30ck590 FIND v(dout0_30) AT=300.025n

.meas tran vdout0_31ck590 FIND v(dout0_31) AT=300.025n

.meas tran vdout0_32ck590 FIND v(dout0_32) AT=300.025n

.meas tran vdout0_33ck590 FIND v(dout0_33) AT=300.025n

.meas tran vdout0_34ck590 FIND v(dout0_34) AT=300.025n

.meas tran vdout0_35ck590 FIND v(dout0_35) AT=300.025n

.meas tran vdout0_36ck590 FIND v(dout0_36) AT=300.025n

.meas tran vdout0_37ck590 FIND v(dout0_37) AT=300.025n

.meas tran vdout0_38ck590 FIND v(dout0_38) AT=300.025n

.meas tran vdout0_39ck590 FIND v(dout0_39) AT=300.025n

.meas tran vdout0_40ck590 FIND v(dout0_40) AT=300.025n

.meas tran vdout0_41ck590 FIND v(dout0_41) AT=300.025n

.meas tran vdout0_42ck590 FIND v(dout0_42) AT=300.025n

.meas tran vdout0_43ck590 FIND v(dout0_43) AT=300.025n

.meas tran vdout0_44ck590 FIND v(dout0_44) AT=300.025n

.meas tran vdout0_45ck590 FIND v(dout0_45) AT=300.025n

.meas tran vdout0_46ck590 FIND v(dout0_46) AT=300.025n

.meas tran vdout0_47ck590 FIND v(dout0_47) AT=300.025n

.meas tran vdout0_48ck590 FIND v(dout0_48) AT=300.025n

.meas tran vdout0_49ck590 FIND v(dout0_49) AT=300.025n

.meas tran vdout0_50ck590 FIND v(dout0_50) AT=300.025n

.meas tran vdout0_51ck590 FIND v(dout0_51) AT=300.025n

.meas tran vdout0_52ck590 FIND v(dout0_52) AT=300.025n

.meas tran vdout0_53ck590 FIND v(dout0_53) AT=300.025n

.meas tran vdout0_54ck590 FIND v(dout0_54) AT=300.025n

.meas tran vdout0_55ck590 FIND v(dout0_55) AT=300.025n

.meas tran vdout0_56ck590 FIND v(dout0_56) AT=300.025n

.meas tran vdout0_57ck590 FIND v(dout0_57) AT=300.025n

.meas tran vdout0_58ck590 FIND v(dout0_58) AT=300.025n

.meas tran vdout0_59ck590 FIND v(dout0_59) AT=300.025n

.meas tran vdout0_60ck590 FIND v(dout0_60) AT=300.025n

.meas tran vdout0_61ck590 FIND v(dout0_61) AT=300.025n

.meas tran vdout0_62ck590 FIND v(dout0_62) AT=300.025n

.meas tran vdout0_63ck590 FIND v(dout0_63) AT=300.025n

.meas tran vdout0_64ck590 FIND v(dout0_64) AT=300.025n

.meas tran vdout0_65ck590 FIND v(dout0_65) AT=300.025n

.meas tran vdout0_66ck590 FIND v(dout0_66) AT=300.025n

.meas tran vdout0_67ck590 FIND v(dout0_67) AT=300.025n

.meas tran vdout0_68ck590 FIND v(dout0_68) AT=300.025n

.meas tran vdout0_69ck590 FIND v(dout0_69) AT=300.025n

.meas tran vdout0_70ck590 FIND v(dout0_70) AT=300.025n

.meas tran vdout0_71ck590 FIND v(dout0_71) AT=300.025n

.meas tran vdout0_72ck590 FIND v(dout0_72) AT=300.025n

.meas tran vdout0_73ck590 FIND v(dout0_73) AT=300.025n

.meas tran vdout0_74ck590 FIND v(dout0_74) AT=300.025n

.meas tran vdout0_75ck590 FIND v(dout0_75) AT=300.025n

.meas tran vdout0_76ck590 FIND v(dout0_76) AT=300.025n

.meas tran vdout0_77ck590 FIND v(dout0_77) AT=300.025n

.meas tran vdout0_78ck590 FIND v(dout0_78) AT=300.025n

.meas tran vdout0_79ck590 FIND v(dout0_79) AT=300.025n

.meas tran vdout0_80ck590 FIND v(dout0_80) AT=300.025n

.meas tran vdout0_81ck590 FIND v(dout0_81) AT=300.025n

.meas tran vdout0_82ck590 FIND v(dout0_82) AT=300.025n

.meas tran vdout0_83ck590 FIND v(dout0_83) AT=300.025n

.meas tran vdout0_84ck590 FIND v(dout0_84) AT=300.025n

.meas tran vdout0_85ck590 FIND v(dout0_85) AT=300.025n

.meas tran vdout0_86ck590 FIND v(dout0_86) AT=300.025n

.meas tran vdout0_87ck590 FIND v(dout0_87) AT=300.025n

.meas tran vdout0_88ck590 FIND v(dout0_88) AT=300.025n

.meas tran vdout0_89ck590 FIND v(dout0_89) AT=300.025n

.meas tran vdout0_90ck590 FIND v(dout0_90) AT=300.025n

.meas tran vdout0_91ck590 FIND v(dout0_91) AT=300.025n

.meas tran vdout0_92ck590 FIND v(dout0_92) AT=300.025n

.meas tran vdout0_93ck590 FIND v(dout0_93) AT=300.025n

.meas tran vdout0_94ck590 FIND v(dout0_94) AT=300.025n

.meas tran vdout0_95ck590 FIND v(dout0_95) AT=300.025n

.meas tran vdout0_96ck590 FIND v(dout0_96) AT=300.025n

.meas tran vdout0_97ck590 FIND v(dout0_97) AT=300.025n

.meas tran vdout0_98ck590 FIND v(dout0_98) AT=300.025n

.meas tran vdout0_99ck590 FIND v(dout0_99) AT=300.025n

.meas tran vdout0_100ck590 FIND v(dout0_100) AT=300.025n

.meas tran vdout0_101ck590 FIND v(dout0_101) AT=300.025n

.meas tran vdout0_102ck590 FIND v(dout0_102) AT=300.025n

.meas tran vdout0_103ck590 FIND v(dout0_103) AT=300.025n

.meas tran vdout0_104ck590 FIND v(dout0_104) AT=300.025n

.meas tran vdout0_105ck590 FIND v(dout0_105) AT=300.025n

.meas tran vdout0_106ck590 FIND v(dout0_106) AT=300.025n

.meas tran vdout0_107ck590 FIND v(dout0_107) AT=300.025n

.meas tran vdout0_108ck590 FIND v(dout0_108) AT=300.025n

.meas tran vdout0_109ck590 FIND v(dout0_109) AT=300.025n

.meas tran vdout0_110ck590 FIND v(dout0_110) AT=300.025n

.meas tran vdout0_111ck590 FIND v(dout0_111) AT=300.025n

.meas tran vdout0_112ck590 FIND v(dout0_112) AT=300.025n

.meas tran vdout0_113ck590 FIND v(dout0_113) AT=300.025n

.meas tran vdout0_114ck590 FIND v(dout0_114) AT=300.025n

.meas tran vdout0_115ck590 FIND v(dout0_115) AT=300.025n

.meas tran vdout0_116ck590 FIND v(dout0_116) AT=300.025n

.meas tran vdout0_117ck590 FIND v(dout0_117) AT=300.025n

.meas tran vdout0_118ck590 FIND v(dout0_118) AT=300.025n

.meas tran vdout0_119ck590 FIND v(dout0_119) AT=300.025n

.meas tran vdout0_120ck590 FIND v(dout0_120) AT=300.025n

.meas tran vdout0_121ck590 FIND v(dout0_121) AT=300.025n

.meas tran vdout0_122ck590 FIND v(dout0_122) AT=300.025n

.meas tran vdout0_123ck590 FIND v(dout0_123) AT=300.025n

.meas tran vdout0_124ck590 FIND v(dout0_124) AT=300.025n

.meas tran vdout0_125ck590 FIND v(dout0_125) AT=300.025n

.meas tran vdout0_126ck590 FIND v(dout0_126) AT=300.025n

.meas tran vdout0_127ck590 FIND v(dout0_127) AT=300.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_0ck630 FIND v(dout0_0) AT=320.025n

.meas tran vdout0_1ck630 FIND v(dout0_1) AT=320.025n

.meas tran vdout0_2ck630 FIND v(dout0_2) AT=320.025n

.meas tran vdout0_3ck630 FIND v(dout0_3) AT=320.025n

.meas tran vdout0_4ck630 FIND v(dout0_4) AT=320.025n

.meas tran vdout0_5ck630 FIND v(dout0_5) AT=320.025n

.meas tran vdout0_6ck630 FIND v(dout0_6) AT=320.025n

.meas tran vdout0_7ck630 FIND v(dout0_7) AT=320.025n

.meas tran vdout0_8ck630 FIND v(dout0_8) AT=320.025n

.meas tran vdout0_9ck630 FIND v(dout0_9) AT=320.025n

.meas tran vdout0_10ck630 FIND v(dout0_10) AT=320.025n

.meas tran vdout0_11ck630 FIND v(dout0_11) AT=320.025n

.meas tran vdout0_12ck630 FIND v(dout0_12) AT=320.025n

.meas tran vdout0_13ck630 FIND v(dout0_13) AT=320.025n

.meas tran vdout0_14ck630 FIND v(dout0_14) AT=320.025n

.meas tran vdout0_15ck630 FIND v(dout0_15) AT=320.025n

.meas tran vdout0_16ck630 FIND v(dout0_16) AT=320.025n

.meas tran vdout0_17ck630 FIND v(dout0_17) AT=320.025n

.meas tran vdout0_18ck630 FIND v(dout0_18) AT=320.025n

.meas tran vdout0_19ck630 FIND v(dout0_19) AT=320.025n

.meas tran vdout0_20ck630 FIND v(dout0_20) AT=320.025n

.meas tran vdout0_21ck630 FIND v(dout0_21) AT=320.025n

.meas tran vdout0_22ck630 FIND v(dout0_22) AT=320.025n

.meas tran vdout0_23ck630 FIND v(dout0_23) AT=320.025n

.meas tran vdout0_24ck630 FIND v(dout0_24) AT=320.025n

.meas tran vdout0_25ck630 FIND v(dout0_25) AT=320.025n

.meas tran vdout0_26ck630 FIND v(dout0_26) AT=320.025n

.meas tran vdout0_27ck630 FIND v(dout0_27) AT=320.025n

.meas tran vdout0_28ck630 FIND v(dout0_28) AT=320.025n

.meas tran vdout0_29ck630 FIND v(dout0_29) AT=320.025n

.meas tran vdout0_30ck630 FIND v(dout0_30) AT=320.025n

.meas tran vdout0_31ck630 FIND v(dout0_31) AT=320.025n

.meas tran vdout0_32ck630 FIND v(dout0_32) AT=320.025n

.meas tran vdout0_33ck630 FIND v(dout0_33) AT=320.025n

.meas tran vdout0_34ck630 FIND v(dout0_34) AT=320.025n

.meas tran vdout0_35ck630 FIND v(dout0_35) AT=320.025n

.meas tran vdout0_36ck630 FIND v(dout0_36) AT=320.025n

.meas tran vdout0_37ck630 FIND v(dout0_37) AT=320.025n

.meas tran vdout0_38ck630 FIND v(dout0_38) AT=320.025n

.meas tran vdout0_39ck630 FIND v(dout0_39) AT=320.025n

.meas tran vdout0_40ck630 FIND v(dout0_40) AT=320.025n

.meas tran vdout0_41ck630 FIND v(dout0_41) AT=320.025n

.meas tran vdout0_42ck630 FIND v(dout0_42) AT=320.025n

.meas tran vdout0_43ck630 FIND v(dout0_43) AT=320.025n

.meas tran vdout0_44ck630 FIND v(dout0_44) AT=320.025n

.meas tran vdout0_45ck630 FIND v(dout0_45) AT=320.025n

.meas tran vdout0_46ck630 FIND v(dout0_46) AT=320.025n

.meas tran vdout0_47ck630 FIND v(dout0_47) AT=320.025n

.meas tran vdout0_48ck630 FIND v(dout0_48) AT=320.025n

.meas tran vdout0_49ck630 FIND v(dout0_49) AT=320.025n

.meas tran vdout0_50ck630 FIND v(dout0_50) AT=320.025n

.meas tran vdout0_51ck630 FIND v(dout0_51) AT=320.025n

.meas tran vdout0_52ck630 FIND v(dout0_52) AT=320.025n

.meas tran vdout0_53ck630 FIND v(dout0_53) AT=320.025n

.meas tran vdout0_54ck630 FIND v(dout0_54) AT=320.025n

.meas tran vdout0_55ck630 FIND v(dout0_55) AT=320.025n

.meas tran vdout0_56ck630 FIND v(dout0_56) AT=320.025n

.meas tran vdout0_57ck630 FIND v(dout0_57) AT=320.025n

.meas tran vdout0_58ck630 FIND v(dout0_58) AT=320.025n

.meas tran vdout0_59ck630 FIND v(dout0_59) AT=320.025n

.meas tran vdout0_60ck630 FIND v(dout0_60) AT=320.025n

.meas tran vdout0_61ck630 FIND v(dout0_61) AT=320.025n

.meas tran vdout0_62ck630 FIND v(dout0_62) AT=320.025n

.meas tran vdout0_63ck630 FIND v(dout0_63) AT=320.025n

.meas tran vdout0_64ck630 FIND v(dout0_64) AT=320.025n

.meas tran vdout0_65ck630 FIND v(dout0_65) AT=320.025n

.meas tran vdout0_66ck630 FIND v(dout0_66) AT=320.025n

.meas tran vdout0_67ck630 FIND v(dout0_67) AT=320.025n

.meas tran vdout0_68ck630 FIND v(dout0_68) AT=320.025n

.meas tran vdout0_69ck630 FIND v(dout0_69) AT=320.025n

.meas tran vdout0_70ck630 FIND v(dout0_70) AT=320.025n

.meas tran vdout0_71ck630 FIND v(dout0_71) AT=320.025n

.meas tran vdout0_72ck630 FIND v(dout0_72) AT=320.025n

.meas tran vdout0_73ck630 FIND v(dout0_73) AT=320.025n

.meas tran vdout0_74ck630 FIND v(dout0_74) AT=320.025n

.meas tran vdout0_75ck630 FIND v(dout0_75) AT=320.025n

.meas tran vdout0_76ck630 FIND v(dout0_76) AT=320.025n

.meas tran vdout0_77ck630 FIND v(dout0_77) AT=320.025n

.meas tran vdout0_78ck630 FIND v(dout0_78) AT=320.025n

.meas tran vdout0_79ck630 FIND v(dout0_79) AT=320.025n

.meas tran vdout0_80ck630 FIND v(dout0_80) AT=320.025n

.meas tran vdout0_81ck630 FIND v(dout0_81) AT=320.025n

.meas tran vdout0_82ck630 FIND v(dout0_82) AT=320.025n

.meas tran vdout0_83ck630 FIND v(dout0_83) AT=320.025n

.meas tran vdout0_84ck630 FIND v(dout0_84) AT=320.025n

.meas tran vdout0_85ck630 FIND v(dout0_85) AT=320.025n

.meas tran vdout0_86ck630 FIND v(dout0_86) AT=320.025n

.meas tran vdout0_87ck630 FIND v(dout0_87) AT=320.025n

.meas tran vdout0_88ck630 FIND v(dout0_88) AT=320.025n

.meas tran vdout0_89ck630 FIND v(dout0_89) AT=320.025n

.meas tran vdout0_90ck630 FIND v(dout0_90) AT=320.025n

.meas tran vdout0_91ck630 FIND v(dout0_91) AT=320.025n

.meas tran vdout0_92ck630 FIND v(dout0_92) AT=320.025n

.meas tran vdout0_93ck630 FIND v(dout0_93) AT=320.025n

.meas tran vdout0_94ck630 FIND v(dout0_94) AT=320.025n

.meas tran vdout0_95ck630 FIND v(dout0_95) AT=320.025n

.meas tran vdout0_96ck630 FIND v(dout0_96) AT=320.025n

.meas tran vdout0_97ck630 FIND v(dout0_97) AT=320.025n

.meas tran vdout0_98ck630 FIND v(dout0_98) AT=320.025n

.meas tran vdout0_99ck630 FIND v(dout0_99) AT=320.025n

.meas tran vdout0_100ck630 FIND v(dout0_100) AT=320.025n

.meas tran vdout0_101ck630 FIND v(dout0_101) AT=320.025n

.meas tran vdout0_102ck630 FIND v(dout0_102) AT=320.025n

.meas tran vdout0_103ck630 FIND v(dout0_103) AT=320.025n

.meas tran vdout0_104ck630 FIND v(dout0_104) AT=320.025n

.meas tran vdout0_105ck630 FIND v(dout0_105) AT=320.025n

.meas tran vdout0_106ck630 FIND v(dout0_106) AT=320.025n

.meas tran vdout0_107ck630 FIND v(dout0_107) AT=320.025n

.meas tran vdout0_108ck630 FIND v(dout0_108) AT=320.025n

.meas tran vdout0_109ck630 FIND v(dout0_109) AT=320.025n

.meas tran vdout0_110ck630 FIND v(dout0_110) AT=320.025n

.meas tran vdout0_111ck630 FIND v(dout0_111) AT=320.025n

.meas tran vdout0_112ck630 FIND v(dout0_112) AT=320.025n

.meas tran vdout0_113ck630 FIND v(dout0_113) AT=320.025n

.meas tran vdout0_114ck630 FIND v(dout0_114) AT=320.025n

.meas tran vdout0_115ck630 FIND v(dout0_115) AT=320.025n

.meas tran vdout0_116ck630 FIND v(dout0_116) AT=320.025n

.meas tran vdout0_117ck630 FIND v(dout0_117) AT=320.025n

.meas tran vdout0_118ck630 FIND v(dout0_118) AT=320.025n

.meas tran vdout0_119ck630 FIND v(dout0_119) AT=320.025n

.meas tran vdout0_120ck630 FIND v(dout0_120) AT=320.025n

.meas tran vdout0_121ck630 FIND v(dout0_121) AT=320.025n

.meas tran vdout0_122ck630 FIND v(dout0_122) AT=320.025n

.meas tran vdout0_123ck630 FIND v(dout0_123) AT=320.025n

.meas tran vdout0_124ck630 FIND v(dout0_124) AT=320.025n

.meas tran vdout0_125ck630 FIND v(dout0_125) AT=320.025n

.meas tran vdout0_126ck630 FIND v(dout0_126) AT=320.025n

.meas tran vdout0_127ck630 FIND v(dout0_127) AT=320.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_0ck720 FIND v(dout0_0) AT=365.025n

.meas tran vdout0_1ck720 FIND v(dout0_1) AT=365.025n

.meas tran vdout0_2ck720 FIND v(dout0_2) AT=365.025n

.meas tran vdout0_3ck720 FIND v(dout0_3) AT=365.025n

.meas tran vdout0_4ck720 FIND v(dout0_4) AT=365.025n

.meas tran vdout0_5ck720 FIND v(dout0_5) AT=365.025n

.meas tran vdout0_6ck720 FIND v(dout0_6) AT=365.025n

.meas tran vdout0_7ck720 FIND v(dout0_7) AT=365.025n

.meas tran vdout0_8ck720 FIND v(dout0_8) AT=365.025n

.meas tran vdout0_9ck720 FIND v(dout0_9) AT=365.025n

.meas tran vdout0_10ck720 FIND v(dout0_10) AT=365.025n

.meas tran vdout0_11ck720 FIND v(dout0_11) AT=365.025n

.meas tran vdout0_12ck720 FIND v(dout0_12) AT=365.025n

.meas tran vdout0_13ck720 FIND v(dout0_13) AT=365.025n

.meas tran vdout0_14ck720 FIND v(dout0_14) AT=365.025n

.meas tran vdout0_15ck720 FIND v(dout0_15) AT=365.025n

.meas tran vdout0_16ck720 FIND v(dout0_16) AT=365.025n

.meas tran vdout0_17ck720 FIND v(dout0_17) AT=365.025n

.meas tran vdout0_18ck720 FIND v(dout0_18) AT=365.025n

.meas tran vdout0_19ck720 FIND v(dout0_19) AT=365.025n

.meas tran vdout0_20ck720 FIND v(dout0_20) AT=365.025n

.meas tran vdout0_21ck720 FIND v(dout0_21) AT=365.025n

.meas tran vdout0_22ck720 FIND v(dout0_22) AT=365.025n

.meas tran vdout0_23ck720 FIND v(dout0_23) AT=365.025n

.meas tran vdout0_24ck720 FIND v(dout0_24) AT=365.025n

.meas tran vdout0_25ck720 FIND v(dout0_25) AT=365.025n

.meas tran vdout0_26ck720 FIND v(dout0_26) AT=365.025n

.meas tran vdout0_27ck720 FIND v(dout0_27) AT=365.025n

.meas tran vdout0_28ck720 FIND v(dout0_28) AT=365.025n

.meas tran vdout0_29ck720 FIND v(dout0_29) AT=365.025n

.meas tran vdout0_30ck720 FIND v(dout0_30) AT=365.025n

.meas tran vdout0_31ck720 FIND v(dout0_31) AT=365.025n

.meas tran vdout0_32ck720 FIND v(dout0_32) AT=365.025n

.meas tran vdout0_33ck720 FIND v(dout0_33) AT=365.025n

.meas tran vdout0_34ck720 FIND v(dout0_34) AT=365.025n

.meas tran vdout0_35ck720 FIND v(dout0_35) AT=365.025n

.meas tran vdout0_36ck720 FIND v(dout0_36) AT=365.025n

.meas tran vdout0_37ck720 FIND v(dout0_37) AT=365.025n

.meas tran vdout0_38ck720 FIND v(dout0_38) AT=365.025n

.meas tran vdout0_39ck720 FIND v(dout0_39) AT=365.025n

.meas tran vdout0_40ck720 FIND v(dout0_40) AT=365.025n

.meas tran vdout0_41ck720 FIND v(dout0_41) AT=365.025n

.meas tran vdout0_42ck720 FIND v(dout0_42) AT=365.025n

.meas tran vdout0_43ck720 FIND v(dout0_43) AT=365.025n

.meas tran vdout0_44ck720 FIND v(dout0_44) AT=365.025n

.meas tran vdout0_45ck720 FIND v(dout0_45) AT=365.025n

.meas tran vdout0_46ck720 FIND v(dout0_46) AT=365.025n

.meas tran vdout0_47ck720 FIND v(dout0_47) AT=365.025n

.meas tran vdout0_48ck720 FIND v(dout0_48) AT=365.025n

.meas tran vdout0_49ck720 FIND v(dout0_49) AT=365.025n

.meas tran vdout0_50ck720 FIND v(dout0_50) AT=365.025n

.meas tran vdout0_51ck720 FIND v(dout0_51) AT=365.025n

.meas tran vdout0_52ck720 FIND v(dout0_52) AT=365.025n

.meas tran vdout0_53ck720 FIND v(dout0_53) AT=365.025n

.meas tran vdout0_54ck720 FIND v(dout0_54) AT=365.025n

.meas tran vdout0_55ck720 FIND v(dout0_55) AT=365.025n

.meas tran vdout0_56ck720 FIND v(dout0_56) AT=365.025n

.meas tran vdout0_57ck720 FIND v(dout0_57) AT=365.025n

.meas tran vdout0_58ck720 FIND v(dout0_58) AT=365.025n

.meas tran vdout0_59ck720 FIND v(dout0_59) AT=365.025n

.meas tran vdout0_60ck720 FIND v(dout0_60) AT=365.025n

.meas tran vdout0_61ck720 FIND v(dout0_61) AT=365.025n

.meas tran vdout0_62ck720 FIND v(dout0_62) AT=365.025n

.meas tran vdout0_63ck720 FIND v(dout0_63) AT=365.025n

.meas tran vdout0_64ck720 FIND v(dout0_64) AT=365.025n

.meas tran vdout0_65ck720 FIND v(dout0_65) AT=365.025n

.meas tran vdout0_66ck720 FIND v(dout0_66) AT=365.025n

.meas tran vdout0_67ck720 FIND v(dout0_67) AT=365.025n

.meas tran vdout0_68ck720 FIND v(dout0_68) AT=365.025n

.meas tran vdout0_69ck720 FIND v(dout0_69) AT=365.025n

.meas tran vdout0_70ck720 FIND v(dout0_70) AT=365.025n

.meas tran vdout0_71ck720 FIND v(dout0_71) AT=365.025n

.meas tran vdout0_72ck720 FIND v(dout0_72) AT=365.025n

.meas tran vdout0_73ck720 FIND v(dout0_73) AT=365.025n

.meas tran vdout0_74ck720 FIND v(dout0_74) AT=365.025n

.meas tran vdout0_75ck720 FIND v(dout0_75) AT=365.025n

.meas tran vdout0_76ck720 FIND v(dout0_76) AT=365.025n

.meas tran vdout0_77ck720 FIND v(dout0_77) AT=365.025n

.meas tran vdout0_78ck720 FIND v(dout0_78) AT=365.025n

.meas tran vdout0_79ck720 FIND v(dout0_79) AT=365.025n

.meas tran vdout0_80ck720 FIND v(dout0_80) AT=365.025n

.meas tran vdout0_81ck720 FIND v(dout0_81) AT=365.025n

.meas tran vdout0_82ck720 FIND v(dout0_82) AT=365.025n

.meas tran vdout0_83ck720 FIND v(dout0_83) AT=365.025n

.meas tran vdout0_84ck720 FIND v(dout0_84) AT=365.025n

.meas tran vdout0_85ck720 FIND v(dout0_85) AT=365.025n

.meas tran vdout0_86ck720 FIND v(dout0_86) AT=365.025n

.meas tran vdout0_87ck720 FIND v(dout0_87) AT=365.025n

.meas tran vdout0_88ck720 FIND v(dout0_88) AT=365.025n

.meas tran vdout0_89ck720 FIND v(dout0_89) AT=365.025n

.meas tran vdout0_90ck720 FIND v(dout0_90) AT=365.025n

.meas tran vdout0_91ck720 FIND v(dout0_91) AT=365.025n

.meas tran vdout0_92ck720 FIND v(dout0_92) AT=365.025n

.meas tran vdout0_93ck720 FIND v(dout0_93) AT=365.025n

.meas tran vdout0_94ck720 FIND v(dout0_94) AT=365.025n

.meas tran vdout0_95ck720 FIND v(dout0_95) AT=365.025n

.meas tran vdout0_96ck720 FIND v(dout0_96) AT=365.025n

.meas tran vdout0_97ck720 FIND v(dout0_97) AT=365.025n

.meas tran vdout0_98ck720 FIND v(dout0_98) AT=365.025n

.meas tran vdout0_99ck720 FIND v(dout0_99) AT=365.025n

.meas tran vdout0_100ck720 FIND v(dout0_100) AT=365.025n

.meas tran vdout0_101ck720 FIND v(dout0_101) AT=365.025n

.meas tran vdout0_102ck720 FIND v(dout0_102) AT=365.025n

.meas tran vdout0_103ck720 FIND v(dout0_103) AT=365.025n

.meas tran vdout0_104ck720 FIND v(dout0_104) AT=365.025n

.meas tran vdout0_105ck720 FIND v(dout0_105) AT=365.025n

.meas tran vdout0_106ck720 FIND v(dout0_106) AT=365.025n

.meas tran vdout0_107ck720 FIND v(dout0_107) AT=365.025n

.meas tran vdout0_108ck720 FIND v(dout0_108) AT=365.025n

.meas tran vdout0_109ck720 FIND v(dout0_109) AT=365.025n

.meas tran vdout0_110ck720 FIND v(dout0_110) AT=365.025n

.meas tran vdout0_111ck720 FIND v(dout0_111) AT=365.025n

.meas tran vdout0_112ck720 FIND v(dout0_112) AT=365.025n

.meas tran vdout0_113ck720 FIND v(dout0_113) AT=365.025n

.meas tran vdout0_114ck720 FIND v(dout0_114) AT=365.025n

.meas tran vdout0_115ck720 FIND v(dout0_115) AT=365.025n

.meas tran vdout0_116ck720 FIND v(dout0_116) AT=365.025n

.meas tran vdout0_117ck720 FIND v(dout0_117) AT=365.025n

.meas tran vdout0_118ck720 FIND v(dout0_118) AT=365.025n

.meas tran vdout0_119ck720 FIND v(dout0_119) AT=365.025n

.meas tran vdout0_120ck720 FIND v(dout0_120) AT=365.025n

.meas tran vdout0_121ck720 FIND v(dout0_121) AT=365.025n

.meas tran vdout0_122ck720 FIND v(dout0_122) AT=365.025n

.meas tran vdout0_123ck720 FIND v(dout0_123) AT=365.025n

.meas tran vdout0_124ck720 FIND v(dout0_124) AT=365.025n

.meas tran vdout0_125ck720 FIND v(dout0_125) AT=365.025n

.meas tran vdout0_126ck720 FIND v(dout0_126) AT=365.025n

.meas tran vdout0_127ck720 FIND v(dout0_127) AT=365.025n

.meas tran vdout0_0ck760 FIND v(dout0_0) AT=385.025n

.meas tran vdout0_1ck760 FIND v(dout0_1) AT=385.025n

.meas tran vdout0_2ck760 FIND v(dout0_2) AT=385.025n

.meas tran vdout0_3ck760 FIND v(dout0_3) AT=385.025n

.meas tran vdout0_4ck760 FIND v(dout0_4) AT=385.025n

.meas tran vdout0_5ck760 FIND v(dout0_5) AT=385.025n

.meas tran vdout0_6ck760 FIND v(dout0_6) AT=385.025n

.meas tran vdout0_7ck760 FIND v(dout0_7) AT=385.025n

.meas tran vdout0_8ck760 FIND v(dout0_8) AT=385.025n

.meas tran vdout0_9ck760 FIND v(dout0_9) AT=385.025n

.meas tran vdout0_10ck760 FIND v(dout0_10) AT=385.025n

.meas tran vdout0_11ck760 FIND v(dout0_11) AT=385.025n

.meas tran vdout0_12ck760 FIND v(dout0_12) AT=385.025n

.meas tran vdout0_13ck760 FIND v(dout0_13) AT=385.025n

.meas tran vdout0_14ck760 FIND v(dout0_14) AT=385.025n

.meas tran vdout0_15ck760 FIND v(dout0_15) AT=385.025n

.meas tran vdout0_16ck760 FIND v(dout0_16) AT=385.025n

.meas tran vdout0_17ck760 FIND v(dout0_17) AT=385.025n

.meas tran vdout0_18ck760 FIND v(dout0_18) AT=385.025n

.meas tran vdout0_19ck760 FIND v(dout0_19) AT=385.025n

.meas tran vdout0_20ck760 FIND v(dout0_20) AT=385.025n

.meas tran vdout0_21ck760 FIND v(dout0_21) AT=385.025n

.meas tran vdout0_22ck760 FIND v(dout0_22) AT=385.025n

.meas tran vdout0_23ck760 FIND v(dout0_23) AT=385.025n

.meas tran vdout0_24ck760 FIND v(dout0_24) AT=385.025n

.meas tran vdout0_25ck760 FIND v(dout0_25) AT=385.025n

.meas tran vdout0_26ck760 FIND v(dout0_26) AT=385.025n

.meas tran vdout0_27ck760 FIND v(dout0_27) AT=385.025n

.meas tran vdout0_28ck760 FIND v(dout0_28) AT=385.025n

.meas tran vdout0_29ck760 FIND v(dout0_29) AT=385.025n

.meas tran vdout0_30ck760 FIND v(dout0_30) AT=385.025n

.meas tran vdout0_31ck760 FIND v(dout0_31) AT=385.025n

.meas tran vdout0_32ck760 FIND v(dout0_32) AT=385.025n

.meas tran vdout0_33ck760 FIND v(dout0_33) AT=385.025n

.meas tran vdout0_34ck760 FIND v(dout0_34) AT=385.025n

.meas tran vdout0_35ck760 FIND v(dout0_35) AT=385.025n

.meas tran vdout0_36ck760 FIND v(dout0_36) AT=385.025n

.meas tran vdout0_37ck760 FIND v(dout0_37) AT=385.025n

.meas tran vdout0_38ck760 FIND v(dout0_38) AT=385.025n

.meas tran vdout0_39ck760 FIND v(dout0_39) AT=385.025n

.meas tran vdout0_40ck760 FIND v(dout0_40) AT=385.025n

.meas tran vdout0_41ck760 FIND v(dout0_41) AT=385.025n

.meas tran vdout0_42ck760 FIND v(dout0_42) AT=385.025n

.meas tran vdout0_43ck760 FIND v(dout0_43) AT=385.025n

.meas tran vdout0_44ck760 FIND v(dout0_44) AT=385.025n

.meas tran vdout0_45ck760 FIND v(dout0_45) AT=385.025n

.meas tran vdout0_46ck760 FIND v(dout0_46) AT=385.025n

.meas tran vdout0_47ck760 FIND v(dout0_47) AT=385.025n

.meas tran vdout0_48ck760 FIND v(dout0_48) AT=385.025n

.meas tran vdout0_49ck760 FIND v(dout0_49) AT=385.025n

.meas tran vdout0_50ck760 FIND v(dout0_50) AT=385.025n

.meas tran vdout0_51ck760 FIND v(dout0_51) AT=385.025n

.meas tran vdout0_52ck760 FIND v(dout0_52) AT=385.025n

.meas tran vdout0_53ck760 FIND v(dout0_53) AT=385.025n

.meas tran vdout0_54ck760 FIND v(dout0_54) AT=385.025n

.meas tran vdout0_55ck760 FIND v(dout0_55) AT=385.025n

.meas tran vdout0_56ck760 FIND v(dout0_56) AT=385.025n

.meas tran vdout0_57ck760 FIND v(dout0_57) AT=385.025n

.meas tran vdout0_58ck760 FIND v(dout0_58) AT=385.025n

.meas tran vdout0_59ck760 FIND v(dout0_59) AT=385.025n

.meas tran vdout0_60ck760 FIND v(dout0_60) AT=385.025n

.meas tran vdout0_61ck760 FIND v(dout0_61) AT=385.025n

.meas tran vdout0_62ck760 FIND v(dout0_62) AT=385.025n

.meas tran vdout0_63ck760 FIND v(dout0_63) AT=385.025n

.meas tran vdout0_64ck760 FIND v(dout0_64) AT=385.025n

.meas tran vdout0_65ck760 FIND v(dout0_65) AT=385.025n

.meas tran vdout0_66ck760 FIND v(dout0_66) AT=385.025n

.meas tran vdout0_67ck760 FIND v(dout0_67) AT=385.025n

.meas tran vdout0_68ck760 FIND v(dout0_68) AT=385.025n

.meas tran vdout0_69ck760 FIND v(dout0_69) AT=385.025n

.meas tran vdout0_70ck760 FIND v(dout0_70) AT=385.025n

.meas tran vdout0_71ck760 FIND v(dout0_71) AT=385.025n

.meas tran vdout0_72ck760 FIND v(dout0_72) AT=385.025n

.meas tran vdout0_73ck760 FIND v(dout0_73) AT=385.025n

.meas tran vdout0_74ck760 FIND v(dout0_74) AT=385.025n

.meas tran vdout0_75ck760 FIND v(dout0_75) AT=385.025n

.meas tran vdout0_76ck760 FIND v(dout0_76) AT=385.025n

.meas tran vdout0_77ck760 FIND v(dout0_77) AT=385.025n

.meas tran vdout0_78ck760 FIND v(dout0_78) AT=385.025n

.meas tran vdout0_79ck760 FIND v(dout0_79) AT=385.025n

.meas tran vdout0_80ck760 FIND v(dout0_80) AT=385.025n

.meas tran vdout0_81ck760 FIND v(dout0_81) AT=385.025n

.meas tran vdout0_82ck760 FIND v(dout0_82) AT=385.025n

.meas tran vdout0_83ck760 FIND v(dout0_83) AT=385.025n

.meas tran vdout0_84ck760 FIND v(dout0_84) AT=385.025n

.meas tran vdout0_85ck760 FIND v(dout0_85) AT=385.025n

.meas tran vdout0_86ck760 FIND v(dout0_86) AT=385.025n

.meas tran vdout0_87ck760 FIND v(dout0_87) AT=385.025n

.meas tran vdout0_88ck760 FIND v(dout0_88) AT=385.025n

.meas tran vdout0_89ck760 FIND v(dout0_89) AT=385.025n

.meas tran vdout0_90ck760 FIND v(dout0_90) AT=385.025n

.meas tran vdout0_91ck760 FIND v(dout0_91) AT=385.025n

.meas tran vdout0_92ck760 FIND v(dout0_92) AT=385.025n

.meas tran vdout0_93ck760 FIND v(dout0_93) AT=385.025n

.meas tran vdout0_94ck760 FIND v(dout0_94) AT=385.025n

.meas tran vdout0_95ck760 FIND v(dout0_95) AT=385.025n

.meas tran vdout0_96ck760 FIND v(dout0_96) AT=385.025n

.meas tran vdout0_97ck760 FIND v(dout0_97) AT=385.025n

.meas tran vdout0_98ck760 FIND v(dout0_98) AT=385.025n

.meas tran vdout0_99ck760 FIND v(dout0_99) AT=385.025n

.meas tran vdout0_100ck760 FIND v(dout0_100) AT=385.025n

.meas tran vdout0_101ck760 FIND v(dout0_101) AT=385.025n

.meas tran vdout0_102ck760 FIND v(dout0_102) AT=385.025n

.meas tran vdout0_103ck760 FIND v(dout0_103) AT=385.025n

.meas tran vdout0_104ck760 FIND v(dout0_104) AT=385.025n

.meas tran vdout0_105ck760 FIND v(dout0_105) AT=385.025n

.meas tran vdout0_106ck760 FIND v(dout0_106) AT=385.025n

.meas tran vdout0_107ck760 FIND v(dout0_107) AT=385.025n

.meas tran vdout0_108ck760 FIND v(dout0_108) AT=385.025n

.meas tran vdout0_109ck760 FIND v(dout0_109) AT=385.025n

.meas tran vdout0_110ck760 FIND v(dout0_110) AT=385.025n

.meas tran vdout0_111ck760 FIND v(dout0_111) AT=385.025n

.meas tran vdout0_112ck760 FIND v(dout0_112) AT=385.025n

.meas tran vdout0_113ck760 FIND v(dout0_113) AT=385.025n

.meas tran vdout0_114ck760 FIND v(dout0_114) AT=385.025n

.meas tran vdout0_115ck760 FIND v(dout0_115) AT=385.025n

.meas tran vdout0_116ck760 FIND v(dout0_116) AT=385.025n

.meas tran vdout0_117ck760 FIND v(dout0_117) AT=385.025n

.meas tran vdout0_118ck760 FIND v(dout0_118) AT=385.025n

.meas tran vdout0_119ck760 FIND v(dout0_119) AT=385.025n

.meas tran vdout0_120ck760 FIND v(dout0_120) AT=385.025n

.meas tran vdout0_121ck760 FIND v(dout0_121) AT=385.025n

.meas tran vdout0_122ck760 FIND v(dout0_122) AT=385.025n

.meas tran vdout0_123ck760 FIND v(dout0_123) AT=385.025n

.meas tran vdout0_124ck760 FIND v(dout0_124) AT=385.025n

.meas tran vdout0_125ck760 FIND v(dout0_125) AT=385.025n

.meas tran vdout0_126ck760 FIND v(dout0_126) AT=385.025n

.meas tran vdout0_127ck760 FIND v(dout0_127) AT=385.025n

.meas tran vdout0_0ck790 FIND v(dout0_0) AT=400.025n

.meas tran vdout0_1ck790 FIND v(dout0_1) AT=400.025n

.meas tran vdout0_2ck790 FIND v(dout0_2) AT=400.025n

.meas tran vdout0_3ck790 FIND v(dout0_3) AT=400.025n

.meas tran vdout0_4ck790 FIND v(dout0_4) AT=400.025n

.meas tran vdout0_5ck790 FIND v(dout0_5) AT=400.025n

.meas tran vdout0_6ck790 FIND v(dout0_6) AT=400.025n

.meas tran vdout0_7ck790 FIND v(dout0_7) AT=400.025n

.meas tran vdout0_8ck790 FIND v(dout0_8) AT=400.025n

.meas tran vdout0_9ck790 FIND v(dout0_9) AT=400.025n

.meas tran vdout0_10ck790 FIND v(dout0_10) AT=400.025n

.meas tran vdout0_11ck790 FIND v(dout0_11) AT=400.025n

.meas tran vdout0_12ck790 FIND v(dout0_12) AT=400.025n

.meas tran vdout0_13ck790 FIND v(dout0_13) AT=400.025n

.meas tran vdout0_14ck790 FIND v(dout0_14) AT=400.025n

.meas tran vdout0_15ck790 FIND v(dout0_15) AT=400.025n

.meas tran vdout0_16ck790 FIND v(dout0_16) AT=400.025n

.meas tran vdout0_17ck790 FIND v(dout0_17) AT=400.025n

.meas tran vdout0_18ck790 FIND v(dout0_18) AT=400.025n

.meas tran vdout0_19ck790 FIND v(dout0_19) AT=400.025n

.meas tran vdout0_20ck790 FIND v(dout0_20) AT=400.025n

.meas tran vdout0_21ck790 FIND v(dout0_21) AT=400.025n

.meas tran vdout0_22ck790 FIND v(dout0_22) AT=400.025n

.meas tran vdout0_23ck790 FIND v(dout0_23) AT=400.025n

.meas tran vdout0_24ck790 FIND v(dout0_24) AT=400.025n

.meas tran vdout0_25ck790 FIND v(dout0_25) AT=400.025n

.meas tran vdout0_26ck790 FIND v(dout0_26) AT=400.025n

.meas tran vdout0_27ck790 FIND v(dout0_27) AT=400.025n

.meas tran vdout0_28ck790 FIND v(dout0_28) AT=400.025n

.meas tran vdout0_29ck790 FIND v(dout0_29) AT=400.025n

.meas tran vdout0_30ck790 FIND v(dout0_30) AT=400.025n

.meas tran vdout0_31ck790 FIND v(dout0_31) AT=400.025n

.meas tran vdout0_32ck790 FIND v(dout0_32) AT=400.025n

.meas tran vdout0_33ck790 FIND v(dout0_33) AT=400.025n

.meas tran vdout0_34ck790 FIND v(dout0_34) AT=400.025n

.meas tran vdout0_35ck790 FIND v(dout0_35) AT=400.025n

.meas tran vdout0_36ck790 FIND v(dout0_36) AT=400.025n

.meas tran vdout0_37ck790 FIND v(dout0_37) AT=400.025n

.meas tran vdout0_38ck790 FIND v(dout0_38) AT=400.025n

.meas tran vdout0_39ck790 FIND v(dout0_39) AT=400.025n

.meas tran vdout0_40ck790 FIND v(dout0_40) AT=400.025n

.meas tran vdout0_41ck790 FIND v(dout0_41) AT=400.025n

.meas tran vdout0_42ck790 FIND v(dout0_42) AT=400.025n

.meas tran vdout0_43ck790 FIND v(dout0_43) AT=400.025n

.meas tran vdout0_44ck790 FIND v(dout0_44) AT=400.025n

.meas tran vdout0_45ck790 FIND v(dout0_45) AT=400.025n

.meas tran vdout0_46ck790 FIND v(dout0_46) AT=400.025n

.meas tran vdout0_47ck790 FIND v(dout0_47) AT=400.025n

.meas tran vdout0_48ck790 FIND v(dout0_48) AT=400.025n

.meas tran vdout0_49ck790 FIND v(dout0_49) AT=400.025n

.meas tran vdout0_50ck790 FIND v(dout0_50) AT=400.025n

.meas tran vdout0_51ck790 FIND v(dout0_51) AT=400.025n

.meas tran vdout0_52ck790 FIND v(dout0_52) AT=400.025n

.meas tran vdout0_53ck790 FIND v(dout0_53) AT=400.025n

.meas tran vdout0_54ck790 FIND v(dout0_54) AT=400.025n

.meas tran vdout0_55ck790 FIND v(dout0_55) AT=400.025n

.meas tran vdout0_56ck790 FIND v(dout0_56) AT=400.025n

.meas tran vdout0_57ck790 FIND v(dout0_57) AT=400.025n

.meas tran vdout0_58ck790 FIND v(dout0_58) AT=400.025n

.meas tran vdout0_59ck790 FIND v(dout0_59) AT=400.025n

.meas tran vdout0_60ck790 FIND v(dout0_60) AT=400.025n

.meas tran vdout0_61ck790 FIND v(dout0_61) AT=400.025n

.meas tran vdout0_62ck790 FIND v(dout0_62) AT=400.025n

.meas tran vdout0_63ck790 FIND v(dout0_63) AT=400.025n

.meas tran vdout0_64ck790 FIND v(dout0_64) AT=400.025n

.meas tran vdout0_65ck790 FIND v(dout0_65) AT=400.025n

.meas tran vdout0_66ck790 FIND v(dout0_66) AT=400.025n

.meas tran vdout0_67ck790 FIND v(dout0_67) AT=400.025n

.meas tran vdout0_68ck790 FIND v(dout0_68) AT=400.025n

.meas tran vdout0_69ck790 FIND v(dout0_69) AT=400.025n

.meas tran vdout0_70ck790 FIND v(dout0_70) AT=400.025n

.meas tran vdout0_71ck790 FIND v(dout0_71) AT=400.025n

.meas tran vdout0_72ck790 FIND v(dout0_72) AT=400.025n

.meas tran vdout0_73ck790 FIND v(dout0_73) AT=400.025n

.meas tran vdout0_74ck790 FIND v(dout0_74) AT=400.025n

.meas tran vdout0_75ck790 FIND v(dout0_75) AT=400.025n

.meas tran vdout0_76ck790 FIND v(dout0_76) AT=400.025n

.meas tran vdout0_77ck790 FIND v(dout0_77) AT=400.025n

.meas tran vdout0_78ck790 FIND v(dout0_78) AT=400.025n

.meas tran vdout0_79ck790 FIND v(dout0_79) AT=400.025n

.meas tran vdout0_80ck790 FIND v(dout0_80) AT=400.025n

.meas tran vdout0_81ck790 FIND v(dout0_81) AT=400.025n

.meas tran vdout0_82ck790 FIND v(dout0_82) AT=400.025n

.meas tran vdout0_83ck790 FIND v(dout0_83) AT=400.025n

.meas tran vdout0_84ck790 FIND v(dout0_84) AT=400.025n

.meas tran vdout0_85ck790 FIND v(dout0_85) AT=400.025n

.meas tran vdout0_86ck790 FIND v(dout0_86) AT=400.025n

.meas tran vdout0_87ck790 FIND v(dout0_87) AT=400.025n

.meas tran vdout0_88ck790 FIND v(dout0_88) AT=400.025n

.meas tran vdout0_89ck790 FIND v(dout0_89) AT=400.025n

.meas tran vdout0_90ck790 FIND v(dout0_90) AT=400.025n

.meas tran vdout0_91ck790 FIND v(dout0_91) AT=400.025n

.meas tran vdout0_92ck790 FIND v(dout0_92) AT=400.025n

.meas tran vdout0_93ck790 FIND v(dout0_93) AT=400.025n

.meas tran vdout0_94ck790 FIND v(dout0_94) AT=400.025n

.meas tran vdout0_95ck790 FIND v(dout0_95) AT=400.025n

.meas tran vdout0_96ck790 FIND v(dout0_96) AT=400.025n

.meas tran vdout0_97ck790 FIND v(dout0_97) AT=400.025n

.meas tran vdout0_98ck790 FIND v(dout0_98) AT=400.025n

.meas tran vdout0_99ck790 FIND v(dout0_99) AT=400.025n

.meas tran vdout0_100ck790 FIND v(dout0_100) AT=400.025n

.meas tran vdout0_101ck790 FIND v(dout0_101) AT=400.025n

.meas tran vdout0_102ck790 FIND v(dout0_102) AT=400.025n

.meas tran vdout0_103ck790 FIND v(dout0_103) AT=400.025n

.meas tran vdout0_104ck790 FIND v(dout0_104) AT=400.025n

.meas tran vdout0_105ck790 FIND v(dout0_105) AT=400.025n

.meas tran vdout0_106ck790 FIND v(dout0_106) AT=400.025n

.meas tran vdout0_107ck790 FIND v(dout0_107) AT=400.025n

.meas tran vdout0_108ck790 FIND v(dout0_108) AT=400.025n

.meas tran vdout0_109ck790 FIND v(dout0_109) AT=400.025n

.meas tran vdout0_110ck790 FIND v(dout0_110) AT=400.025n

.meas tran vdout0_111ck790 FIND v(dout0_111) AT=400.025n

.meas tran vdout0_112ck790 FIND v(dout0_112) AT=400.025n

.meas tran vdout0_113ck790 FIND v(dout0_113) AT=400.025n

.meas tran vdout0_114ck790 FIND v(dout0_114) AT=400.025n

.meas tran vdout0_115ck790 FIND v(dout0_115) AT=400.025n

.meas tran vdout0_116ck790 FIND v(dout0_116) AT=400.025n

.meas tran vdout0_117ck790 FIND v(dout0_117) AT=400.025n

.meas tran vdout0_118ck790 FIND v(dout0_118) AT=400.025n

.meas tran vdout0_119ck790 FIND v(dout0_119) AT=400.025n

.meas tran vdout0_120ck790 FIND v(dout0_120) AT=400.025n

.meas tran vdout0_121ck790 FIND v(dout0_121) AT=400.025n

.meas tran vdout0_122ck790 FIND v(dout0_122) AT=400.025n

.meas tran vdout0_123ck790 FIND v(dout0_123) AT=400.025n

.meas tran vdout0_124ck790 FIND v(dout0_124) AT=400.025n

.meas tran vdout0_125ck790 FIND v(dout0_125) AT=400.025n

.meas tran vdout0_126ck790 FIND v(dout0_126) AT=400.025n

.meas tran vdout0_127ck790 FIND v(dout0_127) AT=400.025n

.meas tran vdout0_0ck810 FIND v(dout0_0) AT=410.025n

.meas tran vdout0_1ck810 FIND v(dout0_1) AT=410.025n

.meas tran vdout0_2ck810 FIND v(dout0_2) AT=410.025n

.meas tran vdout0_3ck810 FIND v(dout0_3) AT=410.025n

.meas tran vdout0_4ck810 FIND v(dout0_4) AT=410.025n

.meas tran vdout0_5ck810 FIND v(dout0_5) AT=410.025n

.meas tran vdout0_6ck810 FIND v(dout0_6) AT=410.025n

.meas tran vdout0_7ck810 FIND v(dout0_7) AT=410.025n

.meas tran vdout0_8ck810 FIND v(dout0_8) AT=410.025n

.meas tran vdout0_9ck810 FIND v(dout0_9) AT=410.025n

.meas tran vdout0_10ck810 FIND v(dout0_10) AT=410.025n

.meas tran vdout0_11ck810 FIND v(dout0_11) AT=410.025n

.meas tran vdout0_12ck810 FIND v(dout0_12) AT=410.025n

.meas tran vdout0_13ck810 FIND v(dout0_13) AT=410.025n

.meas tran vdout0_14ck810 FIND v(dout0_14) AT=410.025n

.meas tran vdout0_15ck810 FIND v(dout0_15) AT=410.025n

.meas tran vdout0_16ck810 FIND v(dout0_16) AT=410.025n

.meas tran vdout0_17ck810 FIND v(dout0_17) AT=410.025n

.meas tran vdout0_18ck810 FIND v(dout0_18) AT=410.025n

.meas tran vdout0_19ck810 FIND v(dout0_19) AT=410.025n

.meas tran vdout0_20ck810 FIND v(dout0_20) AT=410.025n

.meas tran vdout0_21ck810 FIND v(dout0_21) AT=410.025n

.meas tran vdout0_22ck810 FIND v(dout0_22) AT=410.025n

.meas tran vdout0_23ck810 FIND v(dout0_23) AT=410.025n

.meas tran vdout0_24ck810 FIND v(dout0_24) AT=410.025n

.meas tran vdout0_25ck810 FIND v(dout0_25) AT=410.025n

.meas tran vdout0_26ck810 FIND v(dout0_26) AT=410.025n

.meas tran vdout0_27ck810 FIND v(dout0_27) AT=410.025n

.meas tran vdout0_28ck810 FIND v(dout0_28) AT=410.025n

.meas tran vdout0_29ck810 FIND v(dout0_29) AT=410.025n

.meas tran vdout0_30ck810 FIND v(dout0_30) AT=410.025n

.meas tran vdout0_31ck810 FIND v(dout0_31) AT=410.025n

.meas tran vdout0_32ck810 FIND v(dout0_32) AT=410.025n

.meas tran vdout0_33ck810 FIND v(dout0_33) AT=410.025n

.meas tran vdout0_34ck810 FIND v(dout0_34) AT=410.025n

.meas tran vdout0_35ck810 FIND v(dout0_35) AT=410.025n

.meas tran vdout0_36ck810 FIND v(dout0_36) AT=410.025n

.meas tran vdout0_37ck810 FIND v(dout0_37) AT=410.025n

.meas tran vdout0_38ck810 FIND v(dout0_38) AT=410.025n

.meas tran vdout0_39ck810 FIND v(dout0_39) AT=410.025n

.meas tran vdout0_40ck810 FIND v(dout0_40) AT=410.025n

.meas tran vdout0_41ck810 FIND v(dout0_41) AT=410.025n

.meas tran vdout0_42ck810 FIND v(dout0_42) AT=410.025n

.meas tran vdout0_43ck810 FIND v(dout0_43) AT=410.025n

.meas tran vdout0_44ck810 FIND v(dout0_44) AT=410.025n

.meas tran vdout0_45ck810 FIND v(dout0_45) AT=410.025n

.meas tran vdout0_46ck810 FIND v(dout0_46) AT=410.025n

.meas tran vdout0_47ck810 FIND v(dout0_47) AT=410.025n

.meas tran vdout0_48ck810 FIND v(dout0_48) AT=410.025n

.meas tran vdout0_49ck810 FIND v(dout0_49) AT=410.025n

.meas tran vdout0_50ck810 FIND v(dout0_50) AT=410.025n

.meas tran vdout0_51ck810 FIND v(dout0_51) AT=410.025n

.meas tran vdout0_52ck810 FIND v(dout0_52) AT=410.025n

.meas tran vdout0_53ck810 FIND v(dout0_53) AT=410.025n

.meas tran vdout0_54ck810 FIND v(dout0_54) AT=410.025n

.meas tran vdout0_55ck810 FIND v(dout0_55) AT=410.025n

.meas tran vdout0_56ck810 FIND v(dout0_56) AT=410.025n

.meas tran vdout0_57ck810 FIND v(dout0_57) AT=410.025n

.meas tran vdout0_58ck810 FIND v(dout0_58) AT=410.025n

.meas tran vdout0_59ck810 FIND v(dout0_59) AT=410.025n

.meas tran vdout0_60ck810 FIND v(dout0_60) AT=410.025n

.meas tran vdout0_61ck810 FIND v(dout0_61) AT=410.025n

.meas tran vdout0_62ck810 FIND v(dout0_62) AT=410.025n

.meas tran vdout0_63ck810 FIND v(dout0_63) AT=410.025n

.meas tran vdout0_64ck810 FIND v(dout0_64) AT=410.025n

.meas tran vdout0_65ck810 FIND v(dout0_65) AT=410.025n

.meas tran vdout0_66ck810 FIND v(dout0_66) AT=410.025n

.meas tran vdout0_67ck810 FIND v(dout0_67) AT=410.025n

.meas tran vdout0_68ck810 FIND v(dout0_68) AT=410.025n

.meas tran vdout0_69ck810 FIND v(dout0_69) AT=410.025n

.meas tran vdout0_70ck810 FIND v(dout0_70) AT=410.025n

.meas tran vdout0_71ck810 FIND v(dout0_71) AT=410.025n

.meas tran vdout0_72ck810 FIND v(dout0_72) AT=410.025n

.meas tran vdout0_73ck810 FIND v(dout0_73) AT=410.025n

.meas tran vdout0_74ck810 FIND v(dout0_74) AT=410.025n

.meas tran vdout0_75ck810 FIND v(dout0_75) AT=410.025n

.meas tran vdout0_76ck810 FIND v(dout0_76) AT=410.025n

.meas tran vdout0_77ck810 FIND v(dout0_77) AT=410.025n

.meas tran vdout0_78ck810 FIND v(dout0_78) AT=410.025n

.meas tran vdout0_79ck810 FIND v(dout0_79) AT=410.025n

.meas tran vdout0_80ck810 FIND v(dout0_80) AT=410.025n

.meas tran vdout0_81ck810 FIND v(dout0_81) AT=410.025n

.meas tran vdout0_82ck810 FIND v(dout0_82) AT=410.025n

.meas tran vdout0_83ck810 FIND v(dout0_83) AT=410.025n

.meas tran vdout0_84ck810 FIND v(dout0_84) AT=410.025n

.meas tran vdout0_85ck810 FIND v(dout0_85) AT=410.025n

.meas tran vdout0_86ck810 FIND v(dout0_86) AT=410.025n

.meas tran vdout0_87ck810 FIND v(dout0_87) AT=410.025n

.meas tran vdout0_88ck810 FIND v(dout0_88) AT=410.025n

.meas tran vdout0_89ck810 FIND v(dout0_89) AT=410.025n

.meas tran vdout0_90ck810 FIND v(dout0_90) AT=410.025n

.meas tran vdout0_91ck810 FIND v(dout0_91) AT=410.025n

.meas tran vdout0_92ck810 FIND v(dout0_92) AT=410.025n

.meas tran vdout0_93ck810 FIND v(dout0_93) AT=410.025n

.meas tran vdout0_94ck810 FIND v(dout0_94) AT=410.025n

.meas tran vdout0_95ck810 FIND v(dout0_95) AT=410.025n

.meas tran vdout0_96ck810 FIND v(dout0_96) AT=410.025n

.meas tran vdout0_97ck810 FIND v(dout0_97) AT=410.025n

.meas tran vdout0_98ck810 FIND v(dout0_98) AT=410.025n

.meas tran vdout0_99ck810 FIND v(dout0_99) AT=410.025n

.meas tran vdout0_100ck810 FIND v(dout0_100) AT=410.025n

.meas tran vdout0_101ck810 FIND v(dout0_101) AT=410.025n

.meas tran vdout0_102ck810 FIND v(dout0_102) AT=410.025n

.meas tran vdout0_103ck810 FIND v(dout0_103) AT=410.025n

.meas tran vdout0_104ck810 FIND v(dout0_104) AT=410.025n

.meas tran vdout0_105ck810 FIND v(dout0_105) AT=410.025n

.meas tran vdout0_106ck810 FIND v(dout0_106) AT=410.025n

.meas tran vdout0_107ck810 FIND v(dout0_107) AT=410.025n

.meas tran vdout0_108ck810 FIND v(dout0_108) AT=410.025n

.meas tran vdout0_109ck810 FIND v(dout0_109) AT=410.025n

.meas tran vdout0_110ck810 FIND v(dout0_110) AT=410.025n

.meas tran vdout0_111ck810 FIND v(dout0_111) AT=410.025n

.meas tran vdout0_112ck810 FIND v(dout0_112) AT=410.025n

.meas tran vdout0_113ck810 FIND v(dout0_113) AT=410.025n

.meas tran vdout0_114ck810 FIND v(dout0_114) AT=410.025n

.meas tran vdout0_115ck810 FIND v(dout0_115) AT=410.025n

.meas tran vdout0_116ck810 FIND v(dout0_116) AT=410.025n

.meas tran vdout0_117ck810 FIND v(dout0_117) AT=410.025n

.meas tran vdout0_118ck810 FIND v(dout0_118) AT=410.025n

.meas tran vdout0_119ck810 FIND v(dout0_119) AT=410.025n

.meas tran vdout0_120ck810 FIND v(dout0_120) AT=410.025n

.meas tran vdout0_121ck810 FIND v(dout0_121) AT=410.025n

.meas tran vdout0_122ck810 FIND v(dout0_122) AT=410.025n

.meas tran vdout0_123ck810 FIND v(dout0_123) AT=410.025n

.meas tran vdout0_124ck810 FIND v(dout0_124) AT=410.025n

.meas tran vdout0_125ck810 FIND v(dout0_125) AT=410.025n

.meas tran vdout0_126ck810 FIND v(dout0_126) AT=410.025n

.meas tran vdout0_127ck810 FIND v(dout0_127) AT=410.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_0ck830 FIND v(dout0_0) AT=420.025n

.meas tran vdout0_1ck830 FIND v(dout0_1) AT=420.025n

.meas tran vdout0_2ck830 FIND v(dout0_2) AT=420.025n

.meas tran vdout0_3ck830 FIND v(dout0_3) AT=420.025n

.meas tran vdout0_4ck830 FIND v(dout0_4) AT=420.025n

.meas tran vdout0_5ck830 FIND v(dout0_5) AT=420.025n

.meas tran vdout0_6ck830 FIND v(dout0_6) AT=420.025n

.meas tran vdout0_7ck830 FIND v(dout0_7) AT=420.025n

.meas tran vdout0_8ck830 FIND v(dout0_8) AT=420.025n

.meas tran vdout0_9ck830 FIND v(dout0_9) AT=420.025n

.meas tran vdout0_10ck830 FIND v(dout0_10) AT=420.025n

.meas tran vdout0_11ck830 FIND v(dout0_11) AT=420.025n

.meas tran vdout0_12ck830 FIND v(dout0_12) AT=420.025n

.meas tran vdout0_13ck830 FIND v(dout0_13) AT=420.025n

.meas tran vdout0_14ck830 FIND v(dout0_14) AT=420.025n

.meas tran vdout0_15ck830 FIND v(dout0_15) AT=420.025n

.meas tran vdout0_16ck830 FIND v(dout0_16) AT=420.025n

.meas tran vdout0_17ck830 FIND v(dout0_17) AT=420.025n

.meas tran vdout0_18ck830 FIND v(dout0_18) AT=420.025n

.meas tran vdout0_19ck830 FIND v(dout0_19) AT=420.025n

.meas tran vdout0_20ck830 FIND v(dout0_20) AT=420.025n

.meas tran vdout0_21ck830 FIND v(dout0_21) AT=420.025n

.meas tran vdout0_22ck830 FIND v(dout0_22) AT=420.025n

.meas tran vdout0_23ck830 FIND v(dout0_23) AT=420.025n

.meas tran vdout0_24ck830 FIND v(dout0_24) AT=420.025n

.meas tran vdout0_25ck830 FIND v(dout0_25) AT=420.025n

.meas tran vdout0_26ck830 FIND v(dout0_26) AT=420.025n

.meas tran vdout0_27ck830 FIND v(dout0_27) AT=420.025n

.meas tran vdout0_28ck830 FIND v(dout0_28) AT=420.025n

.meas tran vdout0_29ck830 FIND v(dout0_29) AT=420.025n

.meas tran vdout0_30ck830 FIND v(dout0_30) AT=420.025n

.meas tran vdout0_31ck830 FIND v(dout0_31) AT=420.025n

.meas tran vdout0_32ck830 FIND v(dout0_32) AT=420.025n

.meas tran vdout0_33ck830 FIND v(dout0_33) AT=420.025n

.meas tran vdout0_34ck830 FIND v(dout0_34) AT=420.025n

.meas tran vdout0_35ck830 FIND v(dout0_35) AT=420.025n

.meas tran vdout0_36ck830 FIND v(dout0_36) AT=420.025n

.meas tran vdout0_37ck830 FIND v(dout0_37) AT=420.025n

.meas tran vdout0_38ck830 FIND v(dout0_38) AT=420.025n

.meas tran vdout0_39ck830 FIND v(dout0_39) AT=420.025n

.meas tran vdout0_40ck830 FIND v(dout0_40) AT=420.025n

.meas tran vdout0_41ck830 FIND v(dout0_41) AT=420.025n

.meas tran vdout0_42ck830 FIND v(dout0_42) AT=420.025n

.meas tran vdout0_43ck830 FIND v(dout0_43) AT=420.025n

.meas tran vdout0_44ck830 FIND v(dout0_44) AT=420.025n

.meas tran vdout0_45ck830 FIND v(dout0_45) AT=420.025n

.meas tran vdout0_46ck830 FIND v(dout0_46) AT=420.025n

.meas tran vdout0_47ck830 FIND v(dout0_47) AT=420.025n

.meas tran vdout0_48ck830 FIND v(dout0_48) AT=420.025n

.meas tran vdout0_49ck830 FIND v(dout0_49) AT=420.025n

.meas tran vdout0_50ck830 FIND v(dout0_50) AT=420.025n

.meas tran vdout0_51ck830 FIND v(dout0_51) AT=420.025n

.meas tran vdout0_52ck830 FIND v(dout0_52) AT=420.025n

.meas tran vdout0_53ck830 FIND v(dout0_53) AT=420.025n

.meas tran vdout0_54ck830 FIND v(dout0_54) AT=420.025n

.meas tran vdout0_55ck830 FIND v(dout0_55) AT=420.025n

.meas tran vdout0_56ck830 FIND v(dout0_56) AT=420.025n

.meas tran vdout0_57ck830 FIND v(dout0_57) AT=420.025n

.meas tran vdout0_58ck830 FIND v(dout0_58) AT=420.025n

.meas tran vdout0_59ck830 FIND v(dout0_59) AT=420.025n

.meas tran vdout0_60ck830 FIND v(dout0_60) AT=420.025n

.meas tran vdout0_61ck830 FIND v(dout0_61) AT=420.025n

.meas tran vdout0_62ck830 FIND v(dout0_62) AT=420.025n

.meas tran vdout0_63ck830 FIND v(dout0_63) AT=420.025n

.meas tran vdout0_64ck830 FIND v(dout0_64) AT=420.025n

.meas tran vdout0_65ck830 FIND v(dout0_65) AT=420.025n

.meas tran vdout0_66ck830 FIND v(dout0_66) AT=420.025n

.meas tran vdout0_67ck830 FIND v(dout0_67) AT=420.025n

.meas tran vdout0_68ck830 FIND v(dout0_68) AT=420.025n

.meas tran vdout0_69ck830 FIND v(dout0_69) AT=420.025n

.meas tran vdout0_70ck830 FIND v(dout0_70) AT=420.025n

.meas tran vdout0_71ck830 FIND v(dout0_71) AT=420.025n

.meas tran vdout0_72ck830 FIND v(dout0_72) AT=420.025n

.meas tran vdout0_73ck830 FIND v(dout0_73) AT=420.025n

.meas tran vdout0_74ck830 FIND v(dout0_74) AT=420.025n

.meas tran vdout0_75ck830 FIND v(dout0_75) AT=420.025n

.meas tran vdout0_76ck830 FIND v(dout0_76) AT=420.025n

.meas tran vdout0_77ck830 FIND v(dout0_77) AT=420.025n

.meas tran vdout0_78ck830 FIND v(dout0_78) AT=420.025n

.meas tran vdout0_79ck830 FIND v(dout0_79) AT=420.025n

.meas tran vdout0_80ck830 FIND v(dout0_80) AT=420.025n

.meas tran vdout0_81ck830 FIND v(dout0_81) AT=420.025n

.meas tran vdout0_82ck830 FIND v(dout0_82) AT=420.025n

.meas tran vdout0_83ck830 FIND v(dout0_83) AT=420.025n

.meas tran vdout0_84ck830 FIND v(dout0_84) AT=420.025n

.meas tran vdout0_85ck830 FIND v(dout0_85) AT=420.025n

.meas tran vdout0_86ck830 FIND v(dout0_86) AT=420.025n

.meas tran vdout0_87ck830 FIND v(dout0_87) AT=420.025n

.meas tran vdout0_88ck830 FIND v(dout0_88) AT=420.025n

.meas tran vdout0_89ck830 FIND v(dout0_89) AT=420.025n

.meas tran vdout0_90ck830 FIND v(dout0_90) AT=420.025n

.meas tran vdout0_91ck830 FIND v(dout0_91) AT=420.025n

.meas tran vdout0_92ck830 FIND v(dout0_92) AT=420.025n

.meas tran vdout0_93ck830 FIND v(dout0_93) AT=420.025n

.meas tran vdout0_94ck830 FIND v(dout0_94) AT=420.025n

.meas tran vdout0_95ck830 FIND v(dout0_95) AT=420.025n

.meas tran vdout0_96ck830 FIND v(dout0_96) AT=420.025n

.meas tran vdout0_97ck830 FIND v(dout0_97) AT=420.025n

.meas tran vdout0_98ck830 FIND v(dout0_98) AT=420.025n

.meas tran vdout0_99ck830 FIND v(dout0_99) AT=420.025n

.meas tran vdout0_100ck830 FIND v(dout0_100) AT=420.025n

.meas tran vdout0_101ck830 FIND v(dout0_101) AT=420.025n

.meas tran vdout0_102ck830 FIND v(dout0_102) AT=420.025n

.meas tran vdout0_103ck830 FIND v(dout0_103) AT=420.025n

.meas tran vdout0_104ck830 FIND v(dout0_104) AT=420.025n

.meas tran vdout0_105ck830 FIND v(dout0_105) AT=420.025n

.meas tran vdout0_106ck830 FIND v(dout0_106) AT=420.025n

.meas tran vdout0_107ck830 FIND v(dout0_107) AT=420.025n

.meas tran vdout0_108ck830 FIND v(dout0_108) AT=420.025n

.meas tran vdout0_109ck830 FIND v(dout0_109) AT=420.025n

.meas tran vdout0_110ck830 FIND v(dout0_110) AT=420.025n

.meas tran vdout0_111ck830 FIND v(dout0_111) AT=420.025n

.meas tran vdout0_112ck830 FIND v(dout0_112) AT=420.025n

.meas tran vdout0_113ck830 FIND v(dout0_113) AT=420.025n

.meas tran vdout0_114ck830 FIND v(dout0_114) AT=420.025n

.meas tran vdout0_115ck830 FIND v(dout0_115) AT=420.025n

.meas tran vdout0_116ck830 FIND v(dout0_116) AT=420.025n

.meas tran vdout0_117ck830 FIND v(dout0_117) AT=420.025n

.meas tran vdout0_118ck830 FIND v(dout0_118) AT=420.025n

.meas tran vdout0_119ck830 FIND v(dout0_119) AT=420.025n

.meas tran vdout0_120ck830 FIND v(dout0_120) AT=420.025n

.meas tran vdout0_121ck830 FIND v(dout0_121) AT=420.025n

.meas tran vdout0_122ck830 FIND v(dout0_122) AT=420.025n

.meas tran vdout0_123ck830 FIND v(dout0_123) AT=420.025n

.meas tran vdout0_124ck830 FIND v(dout0_124) AT=420.025n

.meas tran vdout0_125ck830 FIND v(dout0_125) AT=420.025n

.meas tran vdout0_126ck830 FIND v(dout0_126) AT=420.025n

.meas tran vdout0_127ck830 FIND v(dout0_127) AT=420.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_0ck890 FIND v(dout0_0) AT=450.025n

.meas tran vdout0_1ck890 FIND v(dout0_1) AT=450.025n

.meas tran vdout0_2ck890 FIND v(dout0_2) AT=450.025n

.meas tran vdout0_3ck890 FIND v(dout0_3) AT=450.025n

.meas tran vdout0_4ck890 FIND v(dout0_4) AT=450.025n

.meas tran vdout0_5ck890 FIND v(dout0_5) AT=450.025n

.meas tran vdout0_6ck890 FIND v(dout0_6) AT=450.025n

.meas tran vdout0_7ck890 FIND v(dout0_7) AT=450.025n

.meas tran vdout0_8ck890 FIND v(dout0_8) AT=450.025n

.meas tran vdout0_9ck890 FIND v(dout0_9) AT=450.025n

.meas tran vdout0_10ck890 FIND v(dout0_10) AT=450.025n

.meas tran vdout0_11ck890 FIND v(dout0_11) AT=450.025n

.meas tran vdout0_12ck890 FIND v(dout0_12) AT=450.025n

.meas tran vdout0_13ck890 FIND v(dout0_13) AT=450.025n

.meas tran vdout0_14ck890 FIND v(dout0_14) AT=450.025n

.meas tran vdout0_15ck890 FIND v(dout0_15) AT=450.025n

.meas tran vdout0_16ck890 FIND v(dout0_16) AT=450.025n

.meas tran vdout0_17ck890 FIND v(dout0_17) AT=450.025n

.meas tran vdout0_18ck890 FIND v(dout0_18) AT=450.025n

.meas tran vdout0_19ck890 FIND v(dout0_19) AT=450.025n

.meas tran vdout0_20ck890 FIND v(dout0_20) AT=450.025n

.meas tran vdout0_21ck890 FIND v(dout0_21) AT=450.025n

.meas tran vdout0_22ck890 FIND v(dout0_22) AT=450.025n

.meas tran vdout0_23ck890 FIND v(dout0_23) AT=450.025n

.meas tran vdout0_24ck890 FIND v(dout0_24) AT=450.025n

.meas tran vdout0_25ck890 FIND v(dout0_25) AT=450.025n

.meas tran vdout0_26ck890 FIND v(dout0_26) AT=450.025n

.meas tran vdout0_27ck890 FIND v(dout0_27) AT=450.025n

.meas tran vdout0_28ck890 FIND v(dout0_28) AT=450.025n

.meas tran vdout0_29ck890 FIND v(dout0_29) AT=450.025n

.meas tran vdout0_30ck890 FIND v(dout0_30) AT=450.025n

.meas tran vdout0_31ck890 FIND v(dout0_31) AT=450.025n

.meas tran vdout0_32ck890 FIND v(dout0_32) AT=450.025n

.meas tran vdout0_33ck890 FIND v(dout0_33) AT=450.025n

.meas tran vdout0_34ck890 FIND v(dout0_34) AT=450.025n

.meas tran vdout0_35ck890 FIND v(dout0_35) AT=450.025n

.meas tran vdout0_36ck890 FIND v(dout0_36) AT=450.025n

.meas tran vdout0_37ck890 FIND v(dout0_37) AT=450.025n

.meas tran vdout0_38ck890 FIND v(dout0_38) AT=450.025n

.meas tran vdout0_39ck890 FIND v(dout0_39) AT=450.025n

.meas tran vdout0_40ck890 FIND v(dout0_40) AT=450.025n

.meas tran vdout0_41ck890 FIND v(dout0_41) AT=450.025n

.meas tran vdout0_42ck890 FIND v(dout0_42) AT=450.025n

.meas tran vdout0_43ck890 FIND v(dout0_43) AT=450.025n

.meas tran vdout0_44ck890 FIND v(dout0_44) AT=450.025n

.meas tran vdout0_45ck890 FIND v(dout0_45) AT=450.025n

.meas tran vdout0_46ck890 FIND v(dout0_46) AT=450.025n

.meas tran vdout0_47ck890 FIND v(dout0_47) AT=450.025n

.meas tran vdout0_48ck890 FIND v(dout0_48) AT=450.025n

.meas tran vdout0_49ck890 FIND v(dout0_49) AT=450.025n

.meas tran vdout0_50ck890 FIND v(dout0_50) AT=450.025n

.meas tran vdout0_51ck890 FIND v(dout0_51) AT=450.025n

.meas tran vdout0_52ck890 FIND v(dout0_52) AT=450.025n

.meas tran vdout0_53ck890 FIND v(dout0_53) AT=450.025n

.meas tran vdout0_54ck890 FIND v(dout0_54) AT=450.025n

.meas tran vdout0_55ck890 FIND v(dout0_55) AT=450.025n

.meas tran vdout0_56ck890 FIND v(dout0_56) AT=450.025n

.meas tran vdout0_57ck890 FIND v(dout0_57) AT=450.025n

.meas tran vdout0_58ck890 FIND v(dout0_58) AT=450.025n

.meas tran vdout0_59ck890 FIND v(dout0_59) AT=450.025n

.meas tran vdout0_60ck890 FIND v(dout0_60) AT=450.025n

.meas tran vdout0_61ck890 FIND v(dout0_61) AT=450.025n

.meas tran vdout0_62ck890 FIND v(dout0_62) AT=450.025n

.meas tran vdout0_63ck890 FIND v(dout0_63) AT=450.025n

.meas tran vdout0_64ck890 FIND v(dout0_64) AT=450.025n

.meas tran vdout0_65ck890 FIND v(dout0_65) AT=450.025n

.meas tran vdout0_66ck890 FIND v(dout0_66) AT=450.025n

.meas tran vdout0_67ck890 FIND v(dout0_67) AT=450.025n

.meas tran vdout0_68ck890 FIND v(dout0_68) AT=450.025n

.meas tran vdout0_69ck890 FIND v(dout0_69) AT=450.025n

.meas tran vdout0_70ck890 FIND v(dout0_70) AT=450.025n

.meas tran vdout0_71ck890 FIND v(dout0_71) AT=450.025n

.meas tran vdout0_72ck890 FIND v(dout0_72) AT=450.025n

.meas tran vdout0_73ck890 FIND v(dout0_73) AT=450.025n

.meas tran vdout0_74ck890 FIND v(dout0_74) AT=450.025n

.meas tran vdout0_75ck890 FIND v(dout0_75) AT=450.025n

.meas tran vdout0_76ck890 FIND v(dout0_76) AT=450.025n

.meas tran vdout0_77ck890 FIND v(dout0_77) AT=450.025n

.meas tran vdout0_78ck890 FIND v(dout0_78) AT=450.025n

.meas tran vdout0_79ck890 FIND v(dout0_79) AT=450.025n

.meas tran vdout0_80ck890 FIND v(dout0_80) AT=450.025n

.meas tran vdout0_81ck890 FIND v(dout0_81) AT=450.025n

.meas tran vdout0_82ck890 FIND v(dout0_82) AT=450.025n

.meas tran vdout0_83ck890 FIND v(dout0_83) AT=450.025n

.meas tran vdout0_84ck890 FIND v(dout0_84) AT=450.025n

.meas tran vdout0_85ck890 FIND v(dout0_85) AT=450.025n

.meas tran vdout0_86ck890 FIND v(dout0_86) AT=450.025n

.meas tran vdout0_87ck890 FIND v(dout0_87) AT=450.025n

.meas tran vdout0_88ck890 FIND v(dout0_88) AT=450.025n

.meas tran vdout0_89ck890 FIND v(dout0_89) AT=450.025n

.meas tran vdout0_90ck890 FIND v(dout0_90) AT=450.025n

.meas tran vdout0_91ck890 FIND v(dout0_91) AT=450.025n

.meas tran vdout0_92ck890 FIND v(dout0_92) AT=450.025n

.meas tran vdout0_93ck890 FIND v(dout0_93) AT=450.025n

.meas tran vdout0_94ck890 FIND v(dout0_94) AT=450.025n

.meas tran vdout0_95ck890 FIND v(dout0_95) AT=450.025n

.meas tran vdout0_96ck890 FIND v(dout0_96) AT=450.025n

.meas tran vdout0_97ck890 FIND v(dout0_97) AT=450.025n

.meas tran vdout0_98ck890 FIND v(dout0_98) AT=450.025n

.meas tran vdout0_99ck890 FIND v(dout0_99) AT=450.025n

.meas tran vdout0_100ck890 FIND v(dout0_100) AT=450.025n

.meas tran vdout0_101ck890 FIND v(dout0_101) AT=450.025n

.meas tran vdout0_102ck890 FIND v(dout0_102) AT=450.025n

.meas tran vdout0_103ck890 FIND v(dout0_103) AT=450.025n

.meas tran vdout0_104ck890 FIND v(dout0_104) AT=450.025n

.meas tran vdout0_105ck890 FIND v(dout0_105) AT=450.025n

.meas tran vdout0_106ck890 FIND v(dout0_106) AT=450.025n

.meas tran vdout0_107ck890 FIND v(dout0_107) AT=450.025n

.meas tran vdout0_108ck890 FIND v(dout0_108) AT=450.025n

.meas tran vdout0_109ck890 FIND v(dout0_109) AT=450.025n

.meas tran vdout0_110ck890 FIND v(dout0_110) AT=450.025n

.meas tran vdout0_111ck890 FIND v(dout0_111) AT=450.025n

.meas tran vdout0_112ck890 FIND v(dout0_112) AT=450.025n

.meas tran vdout0_113ck890 FIND v(dout0_113) AT=450.025n

.meas tran vdout0_114ck890 FIND v(dout0_114) AT=450.025n

.meas tran vdout0_115ck890 FIND v(dout0_115) AT=450.025n

.meas tran vdout0_116ck890 FIND v(dout0_116) AT=450.025n

.meas tran vdout0_117ck890 FIND v(dout0_117) AT=450.025n

.meas tran vdout0_118ck890 FIND v(dout0_118) AT=450.025n

.meas tran vdout0_119ck890 FIND v(dout0_119) AT=450.025n

.meas tran vdout0_120ck890 FIND v(dout0_120) AT=450.025n

.meas tran vdout0_121ck890 FIND v(dout0_121) AT=450.025n

.meas tran vdout0_122ck890 FIND v(dout0_122) AT=450.025n

.meas tran vdout0_123ck890 FIND v(dout0_123) AT=450.025n

.meas tran vdout0_124ck890 FIND v(dout0_124) AT=450.025n

.meas tran vdout0_125ck890 FIND v(dout0_125) AT=450.025n

.meas tran vdout0_126ck890 FIND v(dout0_126) AT=450.025n

.meas tran vdout0_127ck890 FIND v(dout0_127) AT=450.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_0ck970 FIND v(dout0_0) AT=490.025n

.meas tran vdout0_1ck970 FIND v(dout0_1) AT=490.025n

.meas tran vdout0_2ck970 FIND v(dout0_2) AT=490.025n

.meas tran vdout0_3ck970 FIND v(dout0_3) AT=490.025n

.meas tran vdout0_4ck970 FIND v(dout0_4) AT=490.025n

.meas tran vdout0_5ck970 FIND v(dout0_5) AT=490.025n

.meas tran vdout0_6ck970 FIND v(dout0_6) AT=490.025n

.meas tran vdout0_7ck970 FIND v(dout0_7) AT=490.025n

.meas tran vdout0_8ck970 FIND v(dout0_8) AT=490.025n

.meas tran vdout0_9ck970 FIND v(dout0_9) AT=490.025n

.meas tran vdout0_10ck970 FIND v(dout0_10) AT=490.025n

.meas tran vdout0_11ck970 FIND v(dout0_11) AT=490.025n

.meas tran vdout0_12ck970 FIND v(dout0_12) AT=490.025n

.meas tran vdout0_13ck970 FIND v(dout0_13) AT=490.025n

.meas tran vdout0_14ck970 FIND v(dout0_14) AT=490.025n

.meas tran vdout0_15ck970 FIND v(dout0_15) AT=490.025n

.meas tran vdout0_16ck970 FIND v(dout0_16) AT=490.025n

.meas tran vdout0_17ck970 FIND v(dout0_17) AT=490.025n

.meas tran vdout0_18ck970 FIND v(dout0_18) AT=490.025n

.meas tran vdout0_19ck970 FIND v(dout0_19) AT=490.025n

.meas tran vdout0_20ck970 FIND v(dout0_20) AT=490.025n

.meas tran vdout0_21ck970 FIND v(dout0_21) AT=490.025n

.meas tran vdout0_22ck970 FIND v(dout0_22) AT=490.025n

.meas tran vdout0_23ck970 FIND v(dout0_23) AT=490.025n

.meas tran vdout0_24ck970 FIND v(dout0_24) AT=490.025n

.meas tran vdout0_25ck970 FIND v(dout0_25) AT=490.025n

.meas tran vdout0_26ck970 FIND v(dout0_26) AT=490.025n

.meas tran vdout0_27ck970 FIND v(dout0_27) AT=490.025n

.meas tran vdout0_28ck970 FIND v(dout0_28) AT=490.025n

.meas tran vdout0_29ck970 FIND v(dout0_29) AT=490.025n

.meas tran vdout0_30ck970 FIND v(dout0_30) AT=490.025n

.meas tran vdout0_31ck970 FIND v(dout0_31) AT=490.025n

.meas tran vdout0_32ck970 FIND v(dout0_32) AT=490.025n

.meas tran vdout0_33ck970 FIND v(dout0_33) AT=490.025n

.meas tran vdout0_34ck970 FIND v(dout0_34) AT=490.025n

.meas tran vdout0_35ck970 FIND v(dout0_35) AT=490.025n

.meas tran vdout0_36ck970 FIND v(dout0_36) AT=490.025n

.meas tran vdout0_37ck970 FIND v(dout0_37) AT=490.025n

.meas tran vdout0_38ck970 FIND v(dout0_38) AT=490.025n

.meas tran vdout0_39ck970 FIND v(dout0_39) AT=490.025n

.meas tran vdout0_40ck970 FIND v(dout0_40) AT=490.025n

.meas tran vdout0_41ck970 FIND v(dout0_41) AT=490.025n

.meas tran vdout0_42ck970 FIND v(dout0_42) AT=490.025n

.meas tran vdout0_43ck970 FIND v(dout0_43) AT=490.025n

.meas tran vdout0_44ck970 FIND v(dout0_44) AT=490.025n

.meas tran vdout0_45ck970 FIND v(dout0_45) AT=490.025n

.meas tran vdout0_46ck970 FIND v(dout0_46) AT=490.025n

.meas tran vdout0_47ck970 FIND v(dout0_47) AT=490.025n

.meas tran vdout0_48ck970 FIND v(dout0_48) AT=490.025n

.meas tran vdout0_49ck970 FIND v(dout0_49) AT=490.025n

.meas tran vdout0_50ck970 FIND v(dout0_50) AT=490.025n

.meas tran vdout0_51ck970 FIND v(dout0_51) AT=490.025n

.meas tran vdout0_52ck970 FIND v(dout0_52) AT=490.025n

.meas tran vdout0_53ck970 FIND v(dout0_53) AT=490.025n

.meas tran vdout0_54ck970 FIND v(dout0_54) AT=490.025n

.meas tran vdout0_55ck970 FIND v(dout0_55) AT=490.025n

.meas tran vdout0_56ck970 FIND v(dout0_56) AT=490.025n

.meas tran vdout0_57ck970 FIND v(dout0_57) AT=490.025n

.meas tran vdout0_58ck970 FIND v(dout0_58) AT=490.025n

.meas tran vdout0_59ck970 FIND v(dout0_59) AT=490.025n

.meas tran vdout0_60ck970 FIND v(dout0_60) AT=490.025n

.meas tran vdout0_61ck970 FIND v(dout0_61) AT=490.025n

.meas tran vdout0_62ck970 FIND v(dout0_62) AT=490.025n

.meas tran vdout0_63ck970 FIND v(dout0_63) AT=490.025n

.meas tran vdout0_64ck970 FIND v(dout0_64) AT=490.025n

.meas tran vdout0_65ck970 FIND v(dout0_65) AT=490.025n

.meas tran vdout0_66ck970 FIND v(dout0_66) AT=490.025n

.meas tran vdout0_67ck970 FIND v(dout0_67) AT=490.025n

.meas tran vdout0_68ck970 FIND v(dout0_68) AT=490.025n

.meas tran vdout0_69ck970 FIND v(dout0_69) AT=490.025n

.meas tran vdout0_70ck970 FIND v(dout0_70) AT=490.025n

.meas tran vdout0_71ck970 FIND v(dout0_71) AT=490.025n

.meas tran vdout0_72ck970 FIND v(dout0_72) AT=490.025n

.meas tran vdout0_73ck970 FIND v(dout0_73) AT=490.025n

.meas tran vdout0_74ck970 FIND v(dout0_74) AT=490.025n

.meas tran vdout0_75ck970 FIND v(dout0_75) AT=490.025n

.meas tran vdout0_76ck970 FIND v(dout0_76) AT=490.025n

.meas tran vdout0_77ck970 FIND v(dout0_77) AT=490.025n

.meas tran vdout0_78ck970 FIND v(dout0_78) AT=490.025n

.meas tran vdout0_79ck970 FIND v(dout0_79) AT=490.025n

.meas tran vdout0_80ck970 FIND v(dout0_80) AT=490.025n

.meas tran vdout0_81ck970 FIND v(dout0_81) AT=490.025n

.meas tran vdout0_82ck970 FIND v(dout0_82) AT=490.025n

.meas tran vdout0_83ck970 FIND v(dout0_83) AT=490.025n

.meas tran vdout0_84ck970 FIND v(dout0_84) AT=490.025n

.meas tran vdout0_85ck970 FIND v(dout0_85) AT=490.025n

.meas tran vdout0_86ck970 FIND v(dout0_86) AT=490.025n

.meas tran vdout0_87ck970 FIND v(dout0_87) AT=490.025n

.meas tran vdout0_88ck970 FIND v(dout0_88) AT=490.025n

.meas tran vdout0_89ck970 FIND v(dout0_89) AT=490.025n

.meas tran vdout0_90ck970 FIND v(dout0_90) AT=490.025n

.meas tran vdout0_91ck970 FIND v(dout0_91) AT=490.025n

.meas tran vdout0_92ck970 FIND v(dout0_92) AT=490.025n

.meas tran vdout0_93ck970 FIND v(dout0_93) AT=490.025n

.meas tran vdout0_94ck970 FIND v(dout0_94) AT=490.025n

.meas tran vdout0_95ck970 FIND v(dout0_95) AT=490.025n

.meas tran vdout0_96ck970 FIND v(dout0_96) AT=490.025n

.meas tran vdout0_97ck970 FIND v(dout0_97) AT=490.025n

.meas tran vdout0_98ck970 FIND v(dout0_98) AT=490.025n

.meas tran vdout0_99ck970 FIND v(dout0_99) AT=490.025n

.meas tran vdout0_100ck970 FIND v(dout0_100) AT=490.025n

.meas tran vdout0_101ck970 FIND v(dout0_101) AT=490.025n

.meas tran vdout0_102ck970 FIND v(dout0_102) AT=490.025n

.meas tran vdout0_103ck970 FIND v(dout0_103) AT=490.025n

.meas tran vdout0_104ck970 FIND v(dout0_104) AT=490.025n

.meas tran vdout0_105ck970 FIND v(dout0_105) AT=490.025n

.meas tran vdout0_106ck970 FIND v(dout0_106) AT=490.025n

.meas tran vdout0_107ck970 FIND v(dout0_107) AT=490.025n

.meas tran vdout0_108ck970 FIND v(dout0_108) AT=490.025n

.meas tran vdout0_109ck970 FIND v(dout0_109) AT=490.025n

.meas tran vdout0_110ck970 FIND v(dout0_110) AT=490.025n

.meas tran vdout0_111ck970 FIND v(dout0_111) AT=490.025n

.meas tran vdout0_112ck970 FIND v(dout0_112) AT=490.025n

.meas tran vdout0_113ck970 FIND v(dout0_113) AT=490.025n

.meas tran vdout0_114ck970 FIND v(dout0_114) AT=490.025n

.meas tran vdout0_115ck970 FIND v(dout0_115) AT=490.025n

.meas tran vdout0_116ck970 FIND v(dout0_116) AT=490.025n

.meas tran vdout0_117ck970 FIND v(dout0_117) AT=490.025n

.meas tran vdout0_118ck970 FIND v(dout0_118) AT=490.025n

.meas tran vdout0_119ck970 FIND v(dout0_119) AT=490.025n

.meas tran vdout0_120ck970 FIND v(dout0_120) AT=490.025n

.meas tran vdout0_121ck970 FIND v(dout0_121) AT=490.025n

.meas tran vdout0_122ck970 FIND v(dout0_122) AT=490.025n

.meas tran vdout0_123ck970 FIND v(dout0_123) AT=490.025n

.meas tran vdout0_124ck970 FIND v(dout0_124) AT=490.025n

.meas tran vdout0_125ck970 FIND v(dout0_125) AT=490.025n

.meas tran vdout0_126ck970 FIND v(dout0_126) AT=490.025n

.meas tran vdout0_127ck970 FIND v(dout0_127) AT=490.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_0ck990 FIND v(dout0_0) AT=500.025n

.meas tran vdout0_1ck990 FIND v(dout0_1) AT=500.025n

.meas tran vdout0_2ck990 FIND v(dout0_2) AT=500.025n

.meas tran vdout0_3ck990 FIND v(dout0_3) AT=500.025n

.meas tran vdout0_4ck990 FIND v(dout0_4) AT=500.025n

.meas tran vdout0_5ck990 FIND v(dout0_5) AT=500.025n

.meas tran vdout0_6ck990 FIND v(dout0_6) AT=500.025n

.meas tran vdout0_7ck990 FIND v(dout0_7) AT=500.025n

.meas tran vdout0_8ck990 FIND v(dout0_8) AT=500.025n

.meas tran vdout0_9ck990 FIND v(dout0_9) AT=500.025n

.meas tran vdout0_10ck990 FIND v(dout0_10) AT=500.025n

.meas tran vdout0_11ck990 FIND v(dout0_11) AT=500.025n

.meas tran vdout0_12ck990 FIND v(dout0_12) AT=500.025n

.meas tran vdout0_13ck990 FIND v(dout0_13) AT=500.025n

.meas tran vdout0_14ck990 FIND v(dout0_14) AT=500.025n

.meas tran vdout0_15ck990 FIND v(dout0_15) AT=500.025n

.meas tran vdout0_16ck990 FIND v(dout0_16) AT=500.025n

.meas tran vdout0_17ck990 FIND v(dout0_17) AT=500.025n

.meas tran vdout0_18ck990 FIND v(dout0_18) AT=500.025n

.meas tran vdout0_19ck990 FIND v(dout0_19) AT=500.025n

.meas tran vdout0_20ck990 FIND v(dout0_20) AT=500.025n

.meas tran vdout0_21ck990 FIND v(dout0_21) AT=500.025n

.meas tran vdout0_22ck990 FIND v(dout0_22) AT=500.025n

.meas tran vdout0_23ck990 FIND v(dout0_23) AT=500.025n

.meas tran vdout0_24ck990 FIND v(dout0_24) AT=500.025n

.meas tran vdout0_25ck990 FIND v(dout0_25) AT=500.025n

.meas tran vdout0_26ck990 FIND v(dout0_26) AT=500.025n

.meas tran vdout0_27ck990 FIND v(dout0_27) AT=500.025n

.meas tran vdout0_28ck990 FIND v(dout0_28) AT=500.025n

.meas tran vdout0_29ck990 FIND v(dout0_29) AT=500.025n

.meas tran vdout0_30ck990 FIND v(dout0_30) AT=500.025n

.meas tran vdout0_31ck990 FIND v(dout0_31) AT=500.025n

.meas tran vdout0_32ck990 FIND v(dout0_32) AT=500.025n

.meas tran vdout0_33ck990 FIND v(dout0_33) AT=500.025n

.meas tran vdout0_34ck990 FIND v(dout0_34) AT=500.025n

.meas tran vdout0_35ck990 FIND v(dout0_35) AT=500.025n

.meas tran vdout0_36ck990 FIND v(dout0_36) AT=500.025n

.meas tran vdout0_37ck990 FIND v(dout0_37) AT=500.025n

.meas tran vdout0_38ck990 FIND v(dout0_38) AT=500.025n

.meas tran vdout0_39ck990 FIND v(dout0_39) AT=500.025n

.meas tran vdout0_40ck990 FIND v(dout0_40) AT=500.025n

.meas tran vdout0_41ck990 FIND v(dout0_41) AT=500.025n

.meas tran vdout0_42ck990 FIND v(dout0_42) AT=500.025n

.meas tran vdout0_43ck990 FIND v(dout0_43) AT=500.025n

.meas tran vdout0_44ck990 FIND v(dout0_44) AT=500.025n

.meas tran vdout0_45ck990 FIND v(dout0_45) AT=500.025n

.meas tran vdout0_46ck990 FIND v(dout0_46) AT=500.025n

.meas tran vdout0_47ck990 FIND v(dout0_47) AT=500.025n

.meas tran vdout0_48ck990 FIND v(dout0_48) AT=500.025n

.meas tran vdout0_49ck990 FIND v(dout0_49) AT=500.025n

.meas tran vdout0_50ck990 FIND v(dout0_50) AT=500.025n

.meas tran vdout0_51ck990 FIND v(dout0_51) AT=500.025n

.meas tran vdout0_52ck990 FIND v(dout0_52) AT=500.025n

.meas tran vdout0_53ck990 FIND v(dout0_53) AT=500.025n

.meas tran vdout0_54ck990 FIND v(dout0_54) AT=500.025n

.meas tran vdout0_55ck990 FIND v(dout0_55) AT=500.025n

.meas tran vdout0_56ck990 FIND v(dout0_56) AT=500.025n

.meas tran vdout0_57ck990 FIND v(dout0_57) AT=500.025n

.meas tran vdout0_58ck990 FIND v(dout0_58) AT=500.025n

.meas tran vdout0_59ck990 FIND v(dout0_59) AT=500.025n

.meas tran vdout0_60ck990 FIND v(dout0_60) AT=500.025n

.meas tran vdout0_61ck990 FIND v(dout0_61) AT=500.025n

.meas tran vdout0_62ck990 FIND v(dout0_62) AT=500.025n

.meas tran vdout0_63ck990 FIND v(dout0_63) AT=500.025n

.meas tran vdout0_64ck990 FIND v(dout0_64) AT=500.025n

.meas tran vdout0_65ck990 FIND v(dout0_65) AT=500.025n

.meas tran vdout0_66ck990 FIND v(dout0_66) AT=500.025n

.meas tran vdout0_67ck990 FIND v(dout0_67) AT=500.025n

.meas tran vdout0_68ck990 FIND v(dout0_68) AT=500.025n

.meas tran vdout0_69ck990 FIND v(dout0_69) AT=500.025n

.meas tran vdout0_70ck990 FIND v(dout0_70) AT=500.025n

.meas tran vdout0_71ck990 FIND v(dout0_71) AT=500.025n

.meas tran vdout0_72ck990 FIND v(dout0_72) AT=500.025n

.meas tran vdout0_73ck990 FIND v(dout0_73) AT=500.025n

.meas tran vdout0_74ck990 FIND v(dout0_74) AT=500.025n

.meas tran vdout0_75ck990 FIND v(dout0_75) AT=500.025n

.meas tran vdout0_76ck990 FIND v(dout0_76) AT=500.025n

.meas tran vdout0_77ck990 FIND v(dout0_77) AT=500.025n

.meas tran vdout0_78ck990 FIND v(dout0_78) AT=500.025n

.meas tran vdout0_79ck990 FIND v(dout0_79) AT=500.025n

.meas tran vdout0_80ck990 FIND v(dout0_80) AT=500.025n

.meas tran vdout0_81ck990 FIND v(dout0_81) AT=500.025n

.meas tran vdout0_82ck990 FIND v(dout0_82) AT=500.025n

.meas tran vdout0_83ck990 FIND v(dout0_83) AT=500.025n

.meas tran vdout0_84ck990 FIND v(dout0_84) AT=500.025n

.meas tran vdout0_85ck990 FIND v(dout0_85) AT=500.025n

.meas tran vdout0_86ck990 FIND v(dout0_86) AT=500.025n

.meas tran vdout0_87ck990 FIND v(dout0_87) AT=500.025n

.meas tran vdout0_88ck990 FIND v(dout0_88) AT=500.025n

.meas tran vdout0_89ck990 FIND v(dout0_89) AT=500.025n

.meas tran vdout0_90ck990 FIND v(dout0_90) AT=500.025n

.meas tran vdout0_91ck990 FIND v(dout0_91) AT=500.025n

.meas tran vdout0_92ck990 FIND v(dout0_92) AT=500.025n

.meas tran vdout0_93ck990 FIND v(dout0_93) AT=500.025n

.meas tran vdout0_94ck990 FIND v(dout0_94) AT=500.025n

.meas tran vdout0_95ck990 FIND v(dout0_95) AT=500.025n

.meas tran vdout0_96ck990 FIND v(dout0_96) AT=500.025n

.meas tran vdout0_97ck990 FIND v(dout0_97) AT=500.025n

.meas tran vdout0_98ck990 FIND v(dout0_98) AT=500.025n

.meas tran vdout0_99ck990 FIND v(dout0_99) AT=500.025n

.meas tran vdout0_100ck990 FIND v(dout0_100) AT=500.025n

.meas tran vdout0_101ck990 FIND v(dout0_101) AT=500.025n

.meas tran vdout0_102ck990 FIND v(dout0_102) AT=500.025n

.meas tran vdout0_103ck990 FIND v(dout0_103) AT=500.025n

.meas tran vdout0_104ck990 FIND v(dout0_104) AT=500.025n

.meas tran vdout0_105ck990 FIND v(dout0_105) AT=500.025n

.meas tran vdout0_106ck990 FIND v(dout0_106) AT=500.025n

.meas tran vdout0_107ck990 FIND v(dout0_107) AT=500.025n

.meas tran vdout0_108ck990 FIND v(dout0_108) AT=500.025n

.meas tran vdout0_109ck990 FIND v(dout0_109) AT=500.025n

.meas tran vdout0_110ck990 FIND v(dout0_110) AT=500.025n

.meas tran vdout0_111ck990 FIND v(dout0_111) AT=500.025n

.meas tran vdout0_112ck990 FIND v(dout0_112) AT=500.025n

.meas tran vdout0_113ck990 FIND v(dout0_113) AT=500.025n

.meas tran vdout0_114ck990 FIND v(dout0_114) AT=500.025n

.meas tran vdout0_115ck990 FIND v(dout0_115) AT=500.025n

.meas tran vdout0_116ck990 FIND v(dout0_116) AT=500.025n

.meas tran vdout0_117ck990 FIND v(dout0_117) AT=500.025n

.meas tran vdout0_118ck990 FIND v(dout0_118) AT=500.025n

.meas tran vdout0_119ck990 FIND v(dout0_119) AT=500.025n

.meas tran vdout0_120ck990 FIND v(dout0_120) AT=500.025n

.meas tran vdout0_121ck990 FIND v(dout0_121) AT=500.025n

.meas tran vdout0_122ck990 FIND v(dout0_122) AT=500.025n

.meas tran vdout0_123ck990 FIND v(dout0_123) AT=500.025n

.meas tran vdout0_124ck990 FIND v(dout0_124) AT=500.025n

.meas tran vdout0_125ck990 FIND v(dout0_125) AT=500.025n

.meas tran vdout0_126ck990 FIND v(dout0_126) AT=500.025n

.meas tran vdout0_127ck990 FIND v(dout0_127) AT=500.025n

.meas tran vdout0_0ck1000 FIND v(dout0_0) AT=505.025n

.meas tran vdout0_1ck1000 FIND v(dout0_1) AT=505.025n

.meas tran vdout0_2ck1000 FIND v(dout0_2) AT=505.025n

.meas tran vdout0_3ck1000 FIND v(dout0_3) AT=505.025n

.meas tran vdout0_4ck1000 FIND v(dout0_4) AT=505.025n

.meas tran vdout0_5ck1000 FIND v(dout0_5) AT=505.025n

.meas tran vdout0_6ck1000 FIND v(dout0_6) AT=505.025n

.meas tran vdout0_7ck1000 FIND v(dout0_7) AT=505.025n

.meas tran vdout0_8ck1000 FIND v(dout0_8) AT=505.025n

.meas tran vdout0_9ck1000 FIND v(dout0_9) AT=505.025n

.meas tran vdout0_10ck1000 FIND v(dout0_10) AT=505.025n

.meas tran vdout0_11ck1000 FIND v(dout0_11) AT=505.025n

.meas tran vdout0_12ck1000 FIND v(dout0_12) AT=505.025n

.meas tran vdout0_13ck1000 FIND v(dout0_13) AT=505.025n

.meas tran vdout0_14ck1000 FIND v(dout0_14) AT=505.025n

.meas tran vdout0_15ck1000 FIND v(dout0_15) AT=505.025n

.meas tran vdout0_16ck1000 FIND v(dout0_16) AT=505.025n

.meas tran vdout0_17ck1000 FIND v(dout0_17) AT=505.025n

.meas tran vdout0_18ck1000 FIND v(dout0_18) AT=505.025n

.meas tran vdout0_19ck1000 FIND v(dout0_19) AT=505.025n

.meas tran vdout0_20ck1000 FIND v(dout0_20) AT=505.025n

.meas tran vdout0_21ck1000 FIND v(dout0_21) AT=505.025n

.meas tran vdout0_22ck1000 FIND v(dout0_22) AT=505.025n

.meas tran vdout0_23ck1000 FIND v(dout0_23) AT=505.025n

.meas tran vdout0_24ck1000 FIND v(dout0_24) AT=505.025n

.meas tran vdout0_25ck1000 FIND v(dout0_25) AT=505.025n

.meas tran vdout0_26ck1000 FIND v(dout0_26) AT=505.025n

.meas tran vdout0_27ck1000 FIND v(dout0_27) AT=505.025n

.meas tran vdout0_28ck1000 FIND v(dout0_28) AT=505.025n

.meas tran vdout0_29ck1000 FIND v(dout0_29) AT=505.025n

.meas tran vdout0_30ck1000 FIND v(dout0_30) AT=505.025n

.meas tran vdout0_31ck1000 FIND v(dout0_31) AT=505.025n

.meas tran vdout0_32ck1000 FIND v(dout0_32) AT=505.025n

.meas tran vdout0_33ck1000 FIND v(dout0_33) AT=505.025n

.meas tran vdout0_34ck1000 FIND v(dout0_34) AT=505.025n

.meas tran vdout0_35ck1000 FIND v(dout0_35) AT=505.025n

.meas tran vdout0_36ck1000 FIND v(dout0_36) AT=505.025n

.meas tran vdout0_37ck1000 FIND v(dout0_37) AT=505.025n

.meas tran vdout0_38ck1000 FIND v(dout0_38) AT=505.025n

.meas tran vdout0_39ck1000 FIND v(dout0_39) AT=505.025n

.meas tran vdout0_40ck1000 FIND v(dout0_40) AT=505.025n

.meas tran vdout0_41ck1000 FIND v(dout0_41) AT=505.025n

.meas tran vdout0_42ck1000 FIND v(dout0_42) AT=505.025n

.meas tran vdout0_43ck1000 FIND v(dout0_43) AT=505.025n

.meas tran vdout0_44ck1000 FIND v(dout0_44) AT=505.025n

.meas tran vdout0_45ck1000 FIND v(dout0_45) AT=505.025n

.meas tran vdout0_46ck1000 FIND v(dout0_46) AT=505.025n

.meas tran vdout0_47ck1000 FIND v(dout0_47) AT=505.025n

.meas tran vdout0_48ck1000 FIND v(dout0_48) AT=505.025n

.meas tran vdout0_49ck1000 FIND v(dout0_49) AT=505.025n

.meas tran vdout0_50ck1000 FIND v(dout0_50) AT=505.025n

.meas tran vdout0_51ck1000 FIND v(dout0_51) AT=505.025n

.meas tran vdout0_52ck1000 FIND v(dout0_52) AT=505.025n

.meas tran vdout0_53ck1000 FIND v(dout0_53) AT=505.025n

.meas tran vdout0_54ck1000 FIND v(dout0_54) AT=505.025n

.meas tran vdout0_55ck1000 FIND v(dout0_55) AT=505.025n

.meas tran vdout0_56ck1000 FIND v(dout0_56) AT=505.025n

.meas tran vdout0_57ck1000 FIND v(dout0_57) AT=505.025n

.meas tran vdout0_58ck1000 FIND v(dout0_58) AT=505.025n

.meas tran vdout0_59ck1000 FIND v(dout0_59) AT=505.025n

.meas tran vdout0_60ck1000 FIND v(dout0_60) AT=505.025n

.meas tran vdout0_61ck1000 FIND v(dout0_61) AT=505.025n

.meas tran vdout0_62ck1000 FIND v(dout0_62) AT=505.025n

.meas tran vdout0_63ck1000 FIND v(dout0_63) AT=505.025n

.meas tran vdout0_64ck1000 FIND v(dout0_64) AT=505.025n

.meas tran vdout0_65ck1000 FIND v(dout0_65) AT=505.025n

.meas tran vdout0_66ck1000 FIND v(dout0_66) AT=505.025n

.meas tran vdout0_67ck1000 FIND v(dout0_67) AT=505.025n

.meas tran vdout0_68ck1000 FIND v(dout0_68) AT=505.025n

.meas tran vdout0_69ck1000 FIND v(dout0_69) AT=505.025n

.meas tran vdout0_70ck1000 FIND v(dout0_70) AT=505.025n

.meas tran vdout0_71ck1000 FIND v(dout0_71) AT=505.025n

.meas tran vdout0_72ck1000 FIND v(dout0_72) AT=505.025n

.meas tran vdout0_73ck1000 FIND v(dout0_73) AT=505.025n

.meas tran vdout0_74ck1000 FIND v(dout0_74) AT=505.025n

.meas tran vdout0_75ck1000 FIND v(dout0_75) AT=505.025n

.meas tran vdout0_76ck1000 FIND v(dout0_76) AT=505.025n

.meas tran vdout0_77ck1000 FIND v(dout0_77) AT=505.025n

.meas tran vdout0_78ck1000 FIND v(dout0_78) AT=505.025n

.meas tran vdout0_79ck1000 FIND v(dout0_79) AT=505.025n

.meas tran vdout0_80ck1000 FIND v(dout0_80) AT=505.025n

.meas tran vdout0_81ck1000 FIND v(dout0_81) AT=505.025n

.meas tran vdout0_82ck1000 FIND v(dout0_82) AT=505.025n

.meas tran vdout0_83ck1000 FIND v(dout0_83) AT=505.025n

.meas tran vdout0_84ck1000 FIND v(dout0_84) AT=505.025n

.meas tran vdout0_85ck1000 FIND v(dout0_85) AT=505.025n

.meas tran vdout0_86ck1000 FIND v(dout0_86) AT=505.025n

.meas tran vdout0_87ck1000 FIND v(dout0_87) AT=505.025n

.meas tran vdout0_88ck1000 FIND v(dout0_88) AT=505.025n

.meas tran vdout0_89ck1000 FIND v(dout0_89) AT=505.025n

.meas tran vdout0_90ck1000 FIND v(dout0_90) AT=505.025n

.meas tran vdout0_91ck1000 FIND v(dout0_91) AT=505.025n

.meas tran vdout0_92ck1000 FIND v(dout0_92) AT=505.025n

.meas tran vdout0_93ck1000 FIND v(dout0_93) AT=505.025n

.meas tran vdout0_94ck1000 FIND v(dout0_94) AT=505.025n

.meas tran vdout0_95ck1000 FIND v(dout0_95) AT=505.025n

.meas tran vdout0_96ck1000 FIND v(dout0_96) AT=505.025n

.meas tran vdout0_97ck1000 FIND v(dout0_97) AT=505.025n

.meas tran vdout0_98ck1000 FIND v(dout0_98) AT=505.025n

.meas tran vdout0_99ck1000 FIND v(dout0_99) AT=505.025n

.meas tran vdout0_100ck1000 FIND v(dout0_100) AT=505.025n

.meas tran vdout0_101ck1000 FIND v(dout0_101) AT=505.025n

.meas tran vdout0_102ck1000 FIND v(dout0_102) AT=505.025n

.meas tran vdout0_103ck1000 FIND v(dout0_103) AT=505.025n

.meas tran vdout0_104ck1000 FIND v(dout0_104) AT=505.025n

.meas tran vdout0_105ck1000 FIND v(dout0_105) AT=505.025n

.meas tran vdout0_106ck1000 FIND v(dout0_106) AT=505.025n

.meas tran vdout0_107ck1000 FIND v(dout0_107) AT=505.025n

.meas tran vdout0_108ck1000 FIND v(dout0_108) AT=505.025n

.meas tran vdout0_109ck1000 FIND v(dout0_109) AT=505.025n

.meas tran vdout0_110ck1000 FIND v(dout0_110) AT=505.025n

.meas tran vdout0_111ck1000 FIND v(dout0_111) AT=505.025n

.meas tran vdout0_112ck1000 FIND v(dout0_112) AT=505.025n

.meas tran vdout0_113ck1000 FIND v(dout0_113) AT=505.025n

.meas tran vdout0_114ck1000 FIND v(dout0_114) AT=505.025n

.meas tran vdout0_115ck1000 FIND v(dout0_115) AT=505.025n

.meas tran vdout0_116ck1000 FIND v(dout0_116) AT=505.025n

.meas tran vdout0_117ck1000 FIND v(dout0_117) AT=505.025n

.meas tran vdout0_118ck1000 FIND v(dout0_118) AT=505.025n

.meas tran vdout0_119ck1000 FIND v(dout0_119) AT=505.025n

.meas tran vdout0_120ck1000 FIND v(dout0_120) AT=505.025n

.meas tran vdout0_121ck1000 FIND v(dout0_121) AT=505.025n

.meas tran vdout0_122ck1000 FIND v(dout0_122) AT=505.025n

.meas tran vdout0_123ck1000 FIND v(dout0_123) AT=505.025n

.meas tran vdout0_124ck1000 FIND v(dout0_124) AT=505.025n

.meas tran vdout0_125ck1000 FIND v(dout0_125) AT=505.025n

.meas tran vdout0_126ck1000 FIND v(dout0_126) AT=505.025n

.meas tran vdout0_127ck1000 FIND v(dout0_127) AT=505.025n

.meas tran vdout0_0ck1040 FIND v(dout0_0) AT=525.025n

.meas tran vdout0_1ck1040 FIND v(dout0_1) AT=525.025n

.meas tran vdout0_2ck1040 FIND v(dout0_2) AT=525.025n

.meas tran vdout0_3ck1040 FIND v(dout0_3) AT=525.025n

.meas tran vdout0_4ck1040 FIND v(dout0_4) AT=525.025n

.meas tran vdout0_5ck1040 FIND v(dout0_5) AT=525.025n

.meas tran vdout0_6ck1040 FIND v(dout0_6) AT=525.025n

.meas tran vdout0_7ck1040 FIND v(dout0_7) AT=525.025n

.meas tran vdout0_8ck1040 FIND v(dout0_8) AT=525.025n

.meas tran vdout0_9ck1040 FIND v(dout0_9) AT=525.025n

.meas tran vdout0_10ck1040 FIND v(dout0_10) AT=525.025n

.meas tran vdout0_11ck1040 FIND v(dout0_11) AT=525.025n

.meas tran vdout0_12ck1040 FIND v(dout0_12) AT=525.025n

.meas tran vdout0_13ck1040 FIND v(dout0_13) AT=525.025n

.meas tran vdout0_14ck1040 FIND v(dout0_14) AT=525.025n

.meas tran vdout0_15ck1040 FIND v(dout0_15) AT=525.025n

.meas tran vdout0_16ck1040 FIND v(dout0_16) AT=525.025n

.meas tran vdout0_17ck1040 FIND v(dout0_17) AT=525.025n

.meas tran vdout0_18ck1040 FIND v(dout0_18) AT=525.025n

.meas tran vdout0_19ck1040 FIND v(dout0_19) AT=525.025n

.meas tran vdout0_20ck1040 FIND v(dout0_20) AT=525.025n

.meas tran vdout0_21ck1040 FIND v(dout0_21) AT=525.025n

.meas tran vdout0_22ck1040 FIND v(dout0_22) AT=525.025n

.meas tran vdout0_23ck1040 FIND v(dout0_23) AT=525.025n

.meas tran vdout0_24ck1040 FIND v(dout0_24) AT=525.025n

.meas tran vdout0_25ck1040 FIND v(dout0_25) AT=525.025n

.meas tran vdout0_26ck1040 FIND v(dout0_26) AT=525.025n

.meas tran vdout0_27ck1040 FIND v(dout0_27) AT=525.025n

.meas tran vdout0_28ck1040 FIND v(dout0_28) AT=525.025n

.meas tran vdout0_29ck1040 FIND v(dout0_29) AT=525.025n

.meas tran vdout0_30ck1040 FIND v(dout0_30) AT=525.025n

.meas tran vdout0_31ck1040 FIND v(dout0_31) AT=525.025n

.meas tran vdout0_32ck1040 FIND v(dout0_32) AT=525.025n

.meas tran vdout0_33ck1040 FIND v(dout0_33) AT=525.025n

.meas tran vdout0_34ck1040 FIND v(dout0_34) AT=525.025n

.meas tran vdout0_35ck1040 FIND v(dout0_35) AT=525.025n

.meas tran vdout0_36ck1040 FIND v(dout0_36) AT=525.025n

.meas tran vdout0_37ck1040 FIND v(dout0_37) AT=525.025n

.meas tran vdout0_38ck1040 FIND v(dout0_38) AT=525.025n

.meas tran vdout0_39ck1040 FIND v(dout0_39) AT=525.025n

.meas tran vdout0_40ck1040 FIND v(dout0_40) AT=525.025n

.meas tran vdout0_41ck1040 FIND v(dout0_41) AT=525.025n

.meas tran vdout0_42ck1040 FIND v(dout0_42) AT=525.025n

.meas tran vdout0_43ck1040 FIND v(dout0_43) AT=525.025n

.meas tran vdout0_44ck1040 FIND v(dout0_44) AT=525.025n

.meas tran vdout0_45ck1040 FIND v(dout0_45) AT=525.025n

.meas tran vdout0_46ck1040 FIND v(dout0_46) AT=525.025n

.meas tran vdout0_47ck1040 FIND v(dout0_47) AT=525.025n

.meas tran vdout0_48ck1040 FIND v(dout0_48) AT=525.025n

.meas tran vdout0_49ck1040 FIND v(dout0_49) AT=525.025n

.meas tran vdout0_50ck1040 FIND v(dout0_50) AT=525.025n

.meas tran vdout0_51ck1040 FIND v(dout0_51) AT=525.025n

.meas tran vdout0_52ck1040 FIND v(dout0_52) AT=525.025n

.meas tran vdout0_53ck1040 FIND v(dout0_53) AT=525.025n

.meas tran vdout0_54ck1040 FIND v(dout0_54) AT=525.025n

.meas tran vdout0_55ck1040 FIND v(dout0_55) AT=525.025n

.meas tran vdout0_56ck1040 FIND v(dout0_56) AT=525.025n

.meas tran vdout0_57ck1040 FIND v(dout0_57) AT=525.025n

.meas tran vdout0_58ck1040 FIND v(dout0_58) AT=525.025n

.meas tran vdout0_59ck1040 FIND v(dout0_59) AT=525.025n

.meas tran vdout0_60ck1040 FIND v(dout0_60) AT=525.025n

.meas tran vdout0_61ck1040 FIND v(dout0_61) AT=525.025n

.meas tran vdout0_62ck1040 FIND v(dout0_62) AT=525.025n

.meas tran vdout0_63ck1040 FIND v(dout0_63) AT=525.025n

.meas tran vdout0_64ck1040 FIND v(dout0_64) AT=525.025n

.meas tran vdout0_65ck1040 FIND v(dout0_65) AT=525.025n

.meas tran vdout0_66ck1040 FIND v(dout0_66) AT=525.025n

.meas tran vdout0_67ck1040 FIND v(dout0_67) AT=525.025n

.meas tran vdout0_68ck1040 FIND v(dout0_68) AT=525.025n

.meas tran vdout0_69ck1040 FIND v(dout0_69) AT=525.025n

.meas tran vdout0_70ck1040 FIND v(dout0_70) AT=525.025n

.meas tran vdout0_71ck1040 FIND v(dout0_71) AT=525.025n

.meas tran vdout0_72ck1040 FIND v(dout0_72) AT=525.025n

.meas tran vdout0_73ck1040 FIND v(dout0_73) AT=525.025n

.meas tran vdout0_74ck1040 FIND v(dout0_74) AT=525.025n

.meas tran vdout0_75ck1040 FIND v(dout0_75) AT=525.025n

.meas tran vdout0_76ck1040 FIND v(dout0_76) AT=525.025n

.meas tran vdout0_77ck1040 FIND v(dout0_77) AT=525.025n

.meas tran vdout0_78ck1040 FIND v(dout0_78) AT=525.025n

.meas tran vdout0_79ck1040 FIND v(dout0_79) AT=525.025n

.meas tran vdout0_80ck1040 FIND v(dout0_80) AT=525.025n

.meas tran vdout0_81ck1040 FIND v(dout0_81) AT=525.025n

.meas tran vdout0_82ck1040 FIND v(dout0_82) AT=525.025n

.meas tran vdout0_83ck1040 FIND v(dout0_83) AT=525.025n

.meas tran vdout0_84ck1040 FIND v(dout0_84) AT=525.025n

.meas tran vdout0_85ck1040 FIND v(dout0_85) AT=525.025n

.meas tran vdout0_86ck1040 FIND v(dout0_86) AT=525.025n

.meas tran vdout0_87ck1040 FIND v(dout0_87) AT=525.025n

.meas tran vdout0_88ck1040 FIND v(dout0_88) AT=525.025n

.meas tran vdout0_89ck1040 FIND v(dout0_89) AT=525.025n

.meas tran vdout0_90ck1040 FIND v(dout0_90) AT=525.025n

.meas tran vdout0_91ck1040 FIND v(dout0_91) AT=525.025n

.meas tran vdout0_92ck1040 FIND v(dout0_92) AT=525.025n

.meas tran vdout0_93ck1040 FIND v(dout0_93) AT=525.025n

.meas tran vdout0_94ck1040 FIND v(dout0_94) AT=525.025n

.meas tran vdout0_95ck1040 FIND v(dout0_95) AT=525.025n

.meas tran vdout0_96ck1040 FIND v(dout0_96) AT=525.025n

.meas tran vdout0_97ck1040 FIND v(dout0_97) AT=525.025n

.meas tran vdout0_98ck1040 FIND v(dout0_98) AT=525.025n

.meas tran vdout0_99ck1040 FIND v(dout0_99) AT=525.025n

.meas tran vdout0_100ck1040 FIND v(dout0_100) AT=525.025n

.meas tran vdout0_101ck1040 FIND v(dout0_101) AT=525.025n

.meas tran vdout0_102ck1040 FIND v(dout0_102) AT=525.025n

.meas tran vdout0_103ck1040 FIND v(dout0_103) AT=525.025n

.meas tran vdout0_104ck1040 FIND v(dout0_104) AT=525.025n

.meas tran vdout0_105ck1040 FIND v(dout0_105) AT=525.025n

.meas tran vdout0_106ck1040 FIND v(dout0_106) AT=525.025n

.meas tran vdout0_107ck1040 FIND v(dout0_107) AT=525.025n

.meas tran vdout0_108ck1040 FIND v(dout0_108) AT=525.025n

.meas tran vdout0_109ck1040 FIND v(dout0_109) AT=525.025n

.meas tran vdout0_110ck1040 FIND v(dout0_110) AT=525.025n

.meas tran vdout0_111ck1040 FIND v(dout0_111) AT=525.025n

.meas tran vdout0_112ck1040 FIND v(dout0_112) AT=525.025n

.meas tran vdout0_113ck1040 FIND v(dout0_113) AT=525.025n

.meas tran vdout0_114ck1040 FIND v(dout0_114) AT=525.025n

.meas tran vdout0_115ck1040 FIND v(dout0_115) AT=525.025n

.meas tran vdout0_116ck1040 FIND v(dout0_116) AT=525.025n

.meas tran vdout0_117ck1040 FIND v(dout0_117) AT=525.025n

.meas tran vdout0_118ck1040 FIND v(dout0_118) AT=525.025n

.meas tran vdout0_119ck1040 FIND v(dout0_119) AT=525.025n

.meas tran vdout0_120ck1040 FIND v(dout0_120) AT=525.025n

.meas tran vdout0_121ck1040 FIND v(dout0_121) AT=525.025n

.meas tran vdout0_122ck1040 FIND v(dout0_122) AT=525.025n

.meas tran vdout0_123ck1040 FIND v(dout0_123) AT=525.025n

.meas tran vdout0_124ck1040 FIND v(dout0_124) AT=525.025n

.meas tran vdout0_125ck1040 FIND v(dout0_125) AT=525.025n

.meas tran vdout0_126ck1040 FIND v(dout0_126) AT=525.025n

.meas tran vdout0_127ck1040 FIND v(dout0_127) AT=525.025n

.meas tran vdout0_0ck1060 FIND v(dout0_0) AT=535.025n

.meas tran vdout0_1ck1060 FIND v(dout0_1) AT=535.025n

.meas tran vdout0_2ck1060 FIND v(dout0_2) AT=535.025n

.meas tran vdout0_3ck1060 FIND v(dout0_3) AT=535.025n

.meas tran vdout0_4ck1060 FIND v(dout0_4) AT=535.025n

.meas tran vdout0_5ck1060 FIND v(dout0_5) AT=535.025n

.meas tran vdout0_6ck1060 FIND v(dout0_6) AT=535.025n

.meas tran vdout0_7ck1060 FIND v(dout0_7) AT=535.025n

.meas tran vdout0_8ck1060 FIND v(dout0_8) AT=535.025n

.meas tran vdout0_9ck1060 FIND v(dout0_9) AT=535.025n

.meas tran vdout0_10ck1060 FIND v(dout0_10) AT=535.025n

.meas tran vdout0_11ck1060 FIND v(dout0_11) AT=535.025n

.meas tran vdout0_12ck1060 FIND v(dout0_12) AT=535.025n

.meas tran vdout0_13ck1060 FIND v(dout0_13) AT=535.025n

.meas tran vdout0_14ck1060 FIND v(dout0_14) AT=535.025n

.meas tran vdout0_15ck1060 FIND v(dout0_15) AT=535.025n

.meas tran vdout0_16ck1060 FIND v(dout0_16) AT=535.025n

.meas tran vdout0_17ck1060 FIND v(dout0_17) AT=535.025n

.meas tran vdout0_18ck1060 FIND v(dout0_18) AT=535.025n

.meas tran vdout0_19ck1060 FIND v(dout0_19) AT=535.025n

.meas tran vdout0_20ck1060 FIND v(dout0_20) AT=535.025n

.meas tran vdout0_21ck1060 FIND v(dout0_21) AT=535.025n

.meas tran vdout0_22ck1060 FIND v(dout0_22) AT=535.025n

.meas tran vdout0_23ck1060 FIND v(dout0_23) AT=535.025n

.meas tran vdout0_24ck1060 FIND v(dout0_24) AT=535.025n

.meas tran vdout0_25ck1060 FIND v(dout0_25) AT=535.025n

.meas tran vdout0_26ck1060 FIND v(dout0_26) AT=535.025n

.meas tran vdout0_27ck1060 FIND v(dout0_27) AT=535.025n

.meas tran vdout0_28ck1060 FIND v(dout0_28) AT=535.025n

.meas tran vdout0_29ck1060 FIND v(dout0_29) AT=535.025n

.meas tran vdout0_30ck1060 FIND v(dout0_30) AT=535.025n

.meas tran vdout0_31ck1060 FIND v(dout0_31) AT=535.025n

.meas tran vdout0_32ck1060 FIND v(dout0_32) AT=535.025n

.meas tran vdout0_33ck1060 FIND v(dout0_33) AT=535.025n

.meas tran vdout0_34ck1060 FIND v(dout0_34) AT=535.025n

.meas tran vdout0_35ck1060 FIND v(dout0_35) AT=535.025n

.meas tran vdout0_36ck1060 FIND v(dout0_36) AT=535.025n

.meas tran vdout0_37ck1060 FIND v(dout0_37) AT=535.025n

.meas tran vdout0_38ck1060 FIND v(dout0_38) AT=535.025n

.meas tran vdout0_39ck1060 FIND v(dout0_39) AT=535.025n

.meas tran vdout0_40ck1060 FIND v(dout0_40) AT=535.025n

.meas tran vdout0_41ck1060 FIND v(dout0_41) AT=535.025n

.meas tran vdout0_42ck1060 FIND v(dout0_42) AT=535.025n

.meas tran vdout0_43ck1060 FIND v(dout0_43) AT=535.025n

.meas tran vdout0_44ck1060 FIND v(dout0_44) AT=535.025n

.meas tran vdout0_45ck1060 FIND v(dout0_45) AT=535.025n

.meas tran vdout0_46ck1060 FIND v(dout0_46) AT=535.025n

.meas tran vdout0_47ck1060 FIND v(dout0_47) AT=535.025n

.meas tran vdout0_48ck1060 FIND v(dout0_48) AT=535.025n

.meas tran vdout0_49ck1060 FIND v(dout0_49) AT=535.025n

.meas tran vdout0_50ck1060 FIND v(dout0_50) AT=535.025n

.meas tran vdout0_51ck1060 FIND v(dout0_51) AT=535.025n

.meas tran vdout0_52ck1060 FIND v(dout0_52) AT=535.025n

.meas tran vdout0_53ck1060 FIND v(dout0_53) AT=535.025n

.meas tran vdout0_54ck1060 FIND v(dout0_54) AT=535.025n

.meas tran vdout0_55ck1060 FIND v(dout0_55) AT=535.025n

.meas tran vdout0_56ck1060 FIND v(dout0_56) AT=535.025n

.meas tran vdout0_57ck1060 FIND v(dout0_57) AT=535.025n

.meas tran vdout0_58ck1060 FIND v(dout0_58) AT=535.025n

.meas tran vdout0_59ck1060 FIND v(dout0_59) AT=535.025n

.meas tran vdout0_60ck1060 FIND v(dout0_60) AT=535.025n

.meas tran vdout0_61ck1060 FIND v(dout0_61) AT=535.025n

.meas tran vdout0_62ck1060 FIND v(dout0_62) AT=535.025n

.meas tran vdout0_63ck1060 FIND v(dout0_63) AT=535.025n

.meas tran vdout0_64ck1060 FIND v(dout0_64) AT=535.025n

.meas tran vdout0_65ck1060 FIND v(dout0_65) AT=535.025n

.meas tran vdout0_66ck1060 FIND v(dout0_66) AT=535.025n

.meas tran vdout0_67ck1060 FIND v(dout0_67) AT=535.025n

.meas tran vdout0_68ck1060 FIND v(dout0_68) AT=535.025n

.meas tran vdout0_69ck1060 FIND v(dout0_69) AT=535.025n

.meas tran vdout0_70ck1060 FIND v(dout0_70) AT=535.025n

.meas tran vdout0_71ck1060 FIND v(dout0_71) AT=535.025n

.meas tran vdout0_72ck1060 FIND v(dout0_72) AT=535.025n

.meas tran vdout0_73ck1060 FIND v(dout0_73) AT=535.025n

.meas tran vdout0_74ck1060 FIND v(dout0_74) AT=535.025n

.meas tran vdout0_75ck1060 FIND v(dout0_75) AT=535.025n

.meas tran vdout0_76ck1060 FIND v(dout0_76) AT=535.025n

.meas tran vdout0_77ck1060 FIND v(dout0_77) AT=535.025n

.meas tran vdout0_78ck1060 FIND v(dout0_78) AT=535.025n

.meas tran vdout0_79ck1060 FIND v(dout0_79) AT=535.025n

.meas tran vdout0_80ck1060 FIND v(dout0_80) AT=535.025n

.meas tran vdout0_81ck1060 FIND v(dout0_81) AT=535.025n

.meas tran vdout0_82ck1060 FIND v(dout0_82) AT=535.025n

.meas tran vdout0_83ck1060 FIND v(dout0_83) AT=535.025n

.meas tran vdout0_84ck1060 FIND v(dout0_84) AT=535.025n

.meas tran vdout0_85ck1060 FIND v(dout0_85) AT=535.025n

.meas tran vdout0_86ck1060 FIND v(dout0_86) AT=535.025n

.meas tran vdout0_87ck1060 FIND v(dout0_87) AT=535.025n

.meas tran vdout0_88ck1060 FIND v(dout0_88) AT=535.025n

.meas tran vdout0_89ck1060 FIND v(dout0_89) AT=535.025n

.meas tran vdout0_90ck1060 FIND v(dout0_90) AT=535.025n

.meas tran vdout0_91ck1060 FIND v(dout0_91) AT=535.025n

.meas tran vdout0_92ck1060 FIND v(dout0_92) AT=535.025n

.meas tran vdout0_93ck1060 FIND v(dout0_93) AT=535.025n

.meas tran vdout0_94ck1060 FIND v(dout0_94) AT=535.025n

.meas tran vdout0_95ck1060 FIND v(dout0_95) AT=535.025n

.meas tran vdout0_96ck1060 FIND v(dout0_96) AT=535.025n

.meas tran vdout0_97ck1060 FIND v(dout0_97) AT=535.025n

.meas tran vdout0_98ck1060 FIND v(dout0_98) AT=535.025n

.meas tran vdout0_99ck1060 FIND v(dout0_99) AT=535.025n

.meas tran vdout0_100ck1060 FIND v(dout0_100) AT=535.025n

.meas tran vdout0_101ck1060 FIND v(dout0_101) AT=535.025n

.meas tran vdout0_102ck1060 FIND v(dout0_102) AT=535.025n

.meas tran vdout0_103ck1060 FIND v(dout0_103) AT=535.025n

.meas tran vdout0_104ck1060 FIND v(dout0_104) AT=535.025n

.meas tran vdout0_105ck1060 FIND v(dout0_105) AT=535.025n

.meas tran vdout0_106ck1060 FIND v(dout0_106) AT=535.025n

.meas tran vdout0_107ck1060 FIND v(dout0_107) AT=535.025n

.meas tran vdout0_108ck1060 FIND v(dout0_108) AT=535.025n

.meas tran vdout0_109ck1060 FIND v(dout0_109) AT=535.025n

.meas tran vdout0_110ck1060 FIND v(dout0_110) AT=535.025n

.meas tran vdout0_111ck1060 FIND v(dout0_111) AT=535.025n

.meas tran vdout0_112ck1060 FIND v(dout0_112) AT=535.025n

.meas tran vdout0_113ck1060 FIND v(dout0_113) AT=535.025n

.meas tran vdout0_114ck1060 FIND v(dout0_114) AT=535.025n

.meas tran vdout0_115ck1060 FIND v(dout0_115) AT=535.025n

.meas tran vdout0_116ck1060 FIND v(dout0_116) AT=535.025n

.meas tran vdout0_117ck1060 FIND v(dout0_117) AT=535.025n

.meas tran vdout0_118ck1060 FIND v(dout0_118) AT=535.025n

.meas tran vdout0_119ck1060 FIND v(dout0_119) AT=535.025n

.meas tran vdout0_120ck1060 FIND v(dout0_120) AT=535.025n

.meas tran vdout0_121ck1060 FIND v(dout0_121) AT=535.025n

.meas tran vdout0_122ck1060 FIND v(dout0_122) AT=535.025n

.meas tran vdout0_123ck1060 FIND v(dout0_123) AT=535.025n

.meas tran vdout0_124ck1060 FIND v(dout0_124) AT=535.025n

.meas tran vdout0_125ck1060 FIND v(dout0_125) AT=535.025n

.meas tran vdout0_126ck1060 FIND v(dout0_126) AT=535.025n

.meas tran vdout0_127ck1060 FIND v(dout0_127) AT=535.025n

.meas tran vdout0_0ck1070 FIND v(dout0_0) AT=540.025n

.meas tran vdout0_1ck1070 FIND v(dout0_1) AT=540.025n

.meas tran vdout0_2ck1070 FIND v(dout0_2) AT=540.025n

.meas tran vdout0_3ck1070 FIND v(dout0_3) AT=540.025n

.meas tran vdout0_4ck1070 FIND v(dout0_4) AT=540.025n

.meas tran vdout0_5ck1070 FIND v(dout0_5) AT=540.025n

.meas tran vdout0_6ck1070 FIND v(dout0_6) AT=540.025n

.meas tran vdout0_7ck1070 FIND v(dout0_7) AT=540.025n

.meas tran vdout0_8ck1070 FIND v(dout0_8) AT=540.025n

.meas tran vdout0_9ck1070 FIND v(dout0_9) AT=540.025n

.meas tran vdout0_10ck1070 FIND v(dout0_10) AT=540.025n

.meas tran vdout0_11ck1070 FIND v(dout0_11) AT=540.025n

.meas tran vdout0_12ck1070 FIND v(dout0_12) AT=540.025n

.meas tran vdout0_13ck1070 FIND v(dout0_13) AT=540.025n

.meas tran vdout0_14ck1070 FIND v(dout0_14) AT=540.025n

.meas tran vdout0_15ck1070 FIND v(dout0_15) AT=540.025n

.meas tran vdout0_16ck1070 FIND v(dout0_16) AT=540.025n

.meas tran vdout0_17ck1070 FIND v(dout0_17) AT=540.025n

.meas tran vdout0_18ck1070 FIND v(dout0_18) AT=540.025n

.meas tran vdout0_19ck1070 FIND v(dout0_19) AT=540.025n

.meas tran vdout0_20ck1070 FIND v(dout0_20) AT=540.025n

.meas tran vdout0_21ck1070 FIND v(dout0_21) AT=540.025n

.meas tran vdout0_22ck1070 FIND v(dout0_22) AT=540.025n

.meas tran vdout0_23ck1070 FIND v(dout0_23) AT=540.025n

.meas tran vdout0_24ck1070 FIND v(dout0_24) AT=540.025n

.meas tran vdout0_25ck1070 FIND v(dout0_25) AT=540.025n

.meas tran vdout0_26ck1070 FIND v(dout0_26) AT=540.025n

.meas tran vdout0_27ck1070 FIND v(dout0_27) AT=540.025n

.meas tran vdout0_28ck1070 FIND v(dout0_28) AT=540.025n

.meas tran vdout0_29ck1070 FIND v(dout0_29) AT=540.025n

.meas tran vdout0_30ck1070 FIND v(dout0_30) AT=540.025n

.meas tran vdout0_31ck1070 FIND v(dout0_31) AT=540.025n

.meas tran vdout0_32ck1070 FIND v(dout0_32) AT=540.025n

.meas tran vdout0_33ck1070 FIND v(dout0_33) AT=540.025n

.meas tran vdout0_34ck1070 FIND v(dout0_34) AT=540.025n

.meas tran vdout0_35ck1070 FIND v(dout0_35) AT=540.025n

.meas tran vdout0_36ck1070 FIND v(dout0_36) AT=540.025n

.meas tran vdout0_37ck1070 FIND v(dout0_37) AT=540.025n

.meas tran vdout0_38ck1070 FIND v(dout0_38) AT=540.025n

.meas tran vdout0_39ck1070 FIND v(dout0_39) AT=540.025n

.meas tran vdout0_40ck1070 FIND v(dout0_40) AT=540.025n

.meas tran vdout0_41ck1070 FIND v(dout0_41) AT=540.025n

.meas tran vdout0_42ck1070 FIND v(dout0_42) AT=540.025n

.meas tran vdout0_43ck1070 FIND v(dout0_43) AT=540.025n

.meas tran vdout0_44ck1070 FIND v(dout0_44) AT=540.025n

.meas tran vdout0_45ck1070 FIND v(dout0_45) AT=540.025n

.meas tran vdout0_46ck1070 FIND v(dout0_46) AT=540.025n

.meas tran vdout0_47ck1070 FIND v(dout0_47) AT=540.025n

.meas tran vdout0_48ck1070 FIND v(dout0_48) AT=540.025n

.meas tran vdout0_49ck1070 FIND v(dout0_49) AT=540.025n

.meas tran vdout0_50ck1070 FIND v(dout0_50) AT=540.025n

.meas tran vdout0_51ck1070 FIND v(dout0_51) AT=540.025n

.meas tran vdout0_52ck1070 FIND v(dout0_52) AT=540.025n

.meas tran vdout0_53ck1070 FIND v(dout0_53) AT=540.025n

.meas tran vdout0_54ck1070 FIND v(dout0_54) AT=540.025n

.meas tran vdout0_55ck1070 FIND v(dout0_55) AT=540.025n

.meas tran vdout0_56ck1070 FIND v(dout0_56) AT=540.025n

.meas tran vdout0_57ck1070 FIND v(dout0_57) AT=540.025n

.meas tran vdout0_58ck1070 FIND v(dout0_58) AT=540.025n

.meas tran vdout0_59ck1070 FIND v(dout0_59) AT=540.025n

.meas tran vdout0_60ck1070 FIND v(dout0_60) AT=540.025n

.meas tran vdout0_61ck1070 FIND v(dout0_61) AT=540.025n

.meas tran vdout0_62ck1070 FIND v(dout0_62) AT=540.025n

.meas tran vdout0_63ck1070 FIND v(dout0_63) AT=540.025n

.meas tran vdout0_64ck1070 FIND v(dout0_64) AT=540.025n

.meas tran vdout0_65ck1070 FIND v(dout0_65) AT=540.025n

.meas tran vdout0_66ck1070 FIND v(dout0_66) AT=540.025n

.meas tran vdout0_67ck1070 FIND v(dout0_67) AT=540.025n

.meas tran vdout0_68ck1070 FIND v(dout0_68) AT=540.025n

.meas tran vdout0_69ck1070 FIND v(dout0_69) AT=540.025n

.meas tran vdout0_70ck1070 FIND v(dout0_70) AT=540.025n

.meas tran vdout0_71ck1070 FIND v(dout0_71) AT=540.025n

.meas tran vdout0_72ck1070 FIND v(dout0_72) AT=540.025n

.meas tran vdout0_73ck1070 FIND v(dout0_73) AT=540.025n

.meas tran vdout0_74ck1070 FIND v(dout0_74) AT=540.025n

.meas tran vdout0_75ck1070 FIND v(dout0_75) AT=540.025n

.meas tran vdout0_76ck1070 FIND v(dout0_76) AT=540.025n

.meas tran vdout0_77ck1070 FIND v(dout0_77) AT=540.025n

.meas tran vdout0_78ck1070 FIND v(dout0_78) AT=540.025n

.meas tran vdout0_79ck1070 FIND v(dout0_79) AT=540.025n

.meas tran vdout0_80ck1070 FIND v(dout0_80) AT=540.025n

.meas tran vdout0_81ck1070 FIND v(dout0_81) AT=540.025n

.meas tran vdout0_82ck1070 FIND v(dout0_82) AT=540.025n

.meas tran vdout0_83ck1070 FIND v(dout0_83) AT=540.025n

.meas tran vdout0_84ck1070 FIND v(dout0_84) AT=540.025n

.meas tran vdout0_85ck1070 FIND v(dout0_85) AT=540.025n

.meas tran vdout0_86ck1070 FIND v(dout0_86) AT=540.025n

.meas tran vdout0_87ck1070 FIND v(dout0_87) AT=540.025n

.meas tran vdout0_88ck1070 FIND v(dout0_88) AT=540.025n

.meas tran vdout0_89ck1070 FIND v(dout0_89) AT=540.025n

.meas tran vdout0_90ck1070 FIND v(dout0_90) AT=540.025n

.meas tran vdout0_91ck1070 FIND v(dout0_91) AT=540.025n

.meas tran vdout0_92ck1070 FIND v(dout0_92) AT=540.025n

.meas tran vdout0_93ck1070 FIND v(dout0_93) AT=540.025n

.meas tran vdout0_94ck1070 FIND v(dout0_94) AT=540.025n

.meas tran vdout0_95ck1070 FIND v(dout0_95) AT=540.025n

.meas tran vdout0_96ck1070 FIND v(dout0_96) AT=540.025n

.meas tran vdout0_97ck1070 FIND v(dout0_97) AT=540.025n

.meas tran vdout0_98ck1070 FIND v(dout0_98) AT=540.025n

.meas tran vdout0_99ck1070 FIND v(dout0_99) AT=540.025n

.meas tran vdout0_100ck1070 FIND v(dout0_100) AT=540.025n

.meas tran vdout0_101ck1070 FIND v(dout0_101) AT=540.025n

.meas tran vdout0_102ck1070 FIND v(dout0_102) AT=540.025n

.meas tran vdout0_103ck1070 FIND v(dout0_103) AT=540.025n

.meas tran vdout0_104ck1070 FIND v(dout0_104) AT=540.025n

.meas tran vdout0_105ck1070 FIND v(dout0_105) AT=540.025n

.meas tran vdout0_106ck1070 FIND v(dout0_106) AT=540.025n

.meas tran vdout0_107ck1070 FIND v(dout0_107) AT=540.025n

.meas tran vdout0_108ck1070 FIND v(dout0_108) AT=540.025n

.meas tran vdout0_109ck1070 FIND v(dout0_109) AT=540.025n

.meas tran vdout0_110ck1070 FIND v(dout0_110) AT=540.025n

.meas tran vdout0_111ck1070 FIND v(dout0_111) AT=540.025n

.meas tran vdout0_112ck1070 FIND v(dout0_112) AT=540.025n

.meas tran vdout0_113ck1070 FIND v(dout0_113) AT=540.025n

.meas tran vdout0_114ck1070 FIND v(dout0_114) AT=540.025n

.meas tran vdout0_115ck1070 FIND v(dout0_115) AT=540.025n

.meas tran vdout0_116ck1070 FIND v(dout0_116) AT=540.025n

.meas tran vdout0_117ck1070 FIND v(dout0_117) AT=540.025n

.meas tran vdout0_118ck1070 FIND v(dout0_118) AT=540.025n

.meas tran vdout0_119ck1070 FIND v(dout0_119) AT=540.025n

.meas tran vdout0_120ck1070 FIND v(dout0_120) AT=540.025n

.meas tran vdout0_121ck1070 FIND v(dout0_121) AT=540.025n

.meas tran vdout0_122ck1070 FIND v(dout0_122) AT=540.025n

.meas tran vdout0_123ck1070 FIND v(dout0_123) AT=540.025n

.meas tran vdout0_124ck1070 FIND v(dout0_124) AT=540.025n

.meas tran vdout0_125ck1070 FIND v(dout0_125) AT=540.025n

.meas tran vdout0_126ck1070 FIND v(dout0_126) AT=540.025n

.meas tran vdout0_127ck1070 FIND v(dout0_127) AT=540.025n

.meas tran vdout0_0ck1100 FIND v(dout0_0) AT=555.025n

.meas tran vdout0_1ck1100 FIND v(dout0_1) AT=555.025n

.meas tran vdout0_2ck1100 FIND v(dout0_2) AT=555.025n

.meas tran vdout0_3ck1100 FIND v(dout0_3) AT=555.025n

.meas tran vdout0_4ck1100 FIND v(dout0_4) AT=555.025n

.meas tran vdout0_5ck1100 FIND v(dout0_5) AT=555.025n

.meas tran vdout0_6ck1100 FIND v(dout0_6) AT=555.025n

.meas tran vdout0_7ck1100 FIND v(dout0_7) AT=555.025n

.meas tran vdout0_8ck1100 FIND v(dout0_8) AT=555.025n

.meas tran vdout0_9ck1100 FIND v(dout0_9) AT=555.025n

.meas tran vdout0_10ck1100 FIND v(dout0_10) AT=555.025n

.meas tran vdout0_11ck1100 FIND v(dout0_11) AT=555.025n

.meas tran vdout0_12ck1100 FIND v(dout0_12) AT=555.025n

.meas tran vdout0_13ck1100 FIND v(dout0_13) AT=555.025n

.meas tran vdout0_14ck1100 FIND v(dout0_14) AT=555.025n

.meas tran vdout0_15ck1100 FIND v(dout0_15) AT=555.025n

.meas tran vdout0_16ck1100 FIND v(dout0_16) AT=555.025n

.meas tran vdout0_17ck1100 FIND v(dout0_17) AT=555.025n

.meas tran vdout0_18ck1100 FIND v(dout0_18) AT=555.025n

.meas tran vdout0_19ck1100 FIND v(dout0_19) AT=555.025n

.meas tran vdout0_20ck1100 FIND v(dout0_20) AT=555.025n

.meas tran vdout0_21ck1100 FIND v(dout0_21) AT=555.025n

.meas tran vdout0_22ck1100 FIND v(dout0_22) AT=555.025n

.meas tran vdout0_23ck1100 FIND v(dout0_23) AT=555.025n

.meas tran vdout0_24ck1100 FIND v(dout0_24) AT=555.025n

.meas tran vdout0_25ck1100 FIND v(dout0_25) AT=555.025n

.meas tran vdout0_26ck1100 FIND v(dout0_26) AT=555.025n

.meas tran vdout0_27ck1100 FIND v(dout0_27) AT=555.025n

.meas tran vdout0_28ck1100 FIND v(dout0_28) AT=555.025n

.meas tran vdout0_29ck1100 FIND v(dout0_29) AT=555.025n

.meas tran vdout0_30ck1100 FIND v(dout0_30) AT=555.025n

.meas tran vdout0_31ck1100 FIND v(dout0_31) AT=555.025n

.meas tran vdout0_32ck1100 FIND v(dout0_32) AT=555.025n

.meas tran vdout0_33ck1100 FIND v(dout0_33) AT=555.025n

.meas tran vdout0_34ck1100 FIND v(dout0_34) AT=555.025n

.meas tran vdout0_35ck1100 FIND v(dout0_35) AT=555.025n

.meas tran vdout0_36ck1100 FIND v(dout0_36) AT=555.025n

.meas tran vdout0_37ck1100 FIND v(dout0_37) AT=555.025n

.meas tran vdout0_38ck1100 FIND v(dout0_38) AT=555.025n

.meas tran vdout0_39ck1100 FIND v(dout0_39) AT=555.025n

.meas tran vdout0_40ck1100 FIND v(dout0_40) AT=555.025n

.meas tran vdout0_41ck1100 FIND v(dout0_41) AT=555.025n

.meas tran vdout0_42ck1100 FIND v(dout0_42) AT=555.025n

.meas tran vdout0_43ck1100 FIND v(dout0_43) AT=555.025n

.meas tran vdout0_44ck1100 FIND v(dout0_44) AT=555.025n

.meas tran vdout0_45ck1100 FIND v(dout0_45) AT=555.025n

.meas tran vdout0_46ck1100 FIND v(dout0_46) AT=555.025n

.meas tran vdout0_47ck1100 FIND v(dout0_47) AT=555.025n

.meas tran vdout0_48ck1100 FIND v(dout0_48) AT=555.025n

.meas tran vdout0_49ck1100 FIND v(dout0_49) AT=555.025n

.meas tran vdout0_50ck1100 FIND v(dout0_50) AT=555.025n

.meas tran vdout0_51ck1100 FIND v(dout0_51) AT=555.025n

.meas tran vdout0_52ck1100 FIND v(dout0_52) AT=555.025n

.meas tran vdout0_53ck1100 FIND v(dout0_53) AT=555.025n

.meas tran vdout0_54ck1100 FIND v(dout0_54) AT=555.025n

.meas tran vdout0_55ck1100 FIND v(dout0_55) AT=555.025n

.meas tran vdout0_56ck1100 FIND v(dout0_56) AT=555.025n

.meas tran vdout0_57ck1100 FIND v(dout0_57) AT=555.025n

.meas tran vdout0_58ck1100 FIND v(dout0_58) AT=555.025n

.meas tran vdout0_59ck1100 FIND v(dout0_59) AT=555.025n

.meas tran vdout0_60ck1100 FIND v(dout0_60) AT=555.025n

.meas tran vdout0_61ck1100 FIND v(dout0_61) AT=555.025n

.meas tran vdout0_62ck1100 FIND v(dout0_62) AT=555.025n

.meas tran vdout0_63ck1100 FIND v(dout0_63) AT=555.025n

.meas tran vdout0_64ck1100 FIND v(dout0_64) AT=555.025n

.meas tran vdout0_65ck1100 FIND v(dout0_65) AT=555.025n

.meas tran vdout0_66ck1100 FIND v(dout0_66) AT=555.025n

.meas tran vdout0_67ck1100 FIND v(dout0_67) AT=555.025n

.meas tran vdout0_68ck1100 FIND v(dout0_68) AT=555.025n

.meas tran vdout0_69ck1100 FIND v(dout0_69) AT=555.025n

.meas tran vdout0_70ck1100 FIND v(dout0_70) AT=555.025n

.meas tran vdout0_71ck1100 FIND v(dout0_71) AT=555.025n

.meas tran vdout0_72ck1100 FIND v(dout0_72) AT=555.025n

.meas tran vdout0_73ck1100 FIND v(dout0_73) AT=555.025n

.meas tran vdout0_74ck1100 FIND v(dout0_74) AT=555.025n

.meas tran vdout0_75ck1100 FIND v(dout0_75) AT=555.025n

.meas tran vdout0_76ck1100 FIND v(dout0_76) AT=555.025n

.meas tran vdout0_77ck1100 FIND v(dout0_77) AT=555.025n

.meas tran vdout0_78ck1100 FIND v(dout0_78) AT=555.025n

.meas tran vdout0_79ck1100 FIND v(dout0_79) AT=555.025n

.meas tran vdout0_80ck1100 FIND v(dout0_80) AT=555.025n

.meas tran vdout0_81ck1100 FIND v(dout0_81) AT=555.025n

.meas tran vdout0_82ck1100 FIND v(dout0_82) AT=555.025n

.meas tran vdout0_83ck1100 FIND v(dout0_83) AT=555.025n

.meas tran vdout0_84ck1100 FIND v(dout0_84) AT=555.025n

.meas tran vdout0_85ck1100 FIND v(dout0_85) AT=555.025n

.meas tran vdout0_86ck1100 FIND v(dout0_86) AT=555.025n

.meas tran vdout0_87ck1100 FIND v(dout0_87) AT=555.025n

.meas tran vdout0_88ck1100 FIND v(dout0_88) AT=555.025n

.meas tran vdout0_89ck1100 FIND v(dout0_89) AT=555.025n

.meas tran vdout0_90ck1100 FIND v(dout0_90) AT=555.025n

.meas tran vdout0_91ck1100 FIND v(dout0_91) AT=555.025n

.meas tran vdout0_92ck1100 FIND v(dout0_92) AT=555.025n

.meas tran vdout0_93ck1100 FIND v(dout0_93) AT=555.025n

.meas tran vdout0_94ck1100 FIND v(dout0_94) AT=555.025n

.meas tran vdout0_95ck1100 FIND v(dout0_95) AT=555.025n

.meas tran vdout0_96ck1100 FIND v(dout0_96) AT=555.025n

.meas tran vdout0_97ck1100 FIND v(dout0_97) AT=555.025n

.meas tran vdout0_98ck1100 FIND v(dout0_98) AT=555.025n

.meas tran vdout0_99ck1100 FIND v(dout0_99) AT=555.025n

.meas tran vdout0_100ck1100 FIND v(dout0_100) AT=555.025n

.meas tran vdout0_101ck1100 FIND v(dout0_101) AT=555.025n

.meas tran vdout0_102ck1100 FIND v(dout0_102) AT=555.025n

.meas tran vdout0_103ck1100 FIND v(dout0_103) AT=555.025n

.meas tran vdout0_104ck1100 FIND v(dout0_104) AT=555.025n

.meas tran vdout0_105ck1100 FIND v(dout0_105) AT=555.025n

.meas tran vdout0_106ck1100 FIND v(dout0_106) AT=555.025n

.meas tran vdout0_107ck1100 FIND v(dout0_107) AT=555.025n

.meas tran vdout0_108ck1100 FIND v(dout0_108) AT=555.025n

.meas tran vdout0_109ck1100 FIND v(dout0_109) AT=555.025n

.meas tran vdout0_110ck1100 FIND v(dout0_110) AT=555.025n

.meas tran vdout0_111ck1100 FIND v(dout0_111) AT=555.025n

.meas tran vdout0_112ck1100 FIND v(dout0_112) AT=555.025n

.meas tran vdout0_113ck1100 FIND v(dout0_113) AT=555.025n

.meas tran vdout0_114ck1100 FIND v(dout0_114) AT=555.025n

.meas tran vdout0_115ck1100 FIND v(dout0_115) AT=555.025n

.meas tran vdout0_116ck1100 FIND v(dout0_116) AT=555.025n

.meas tran vdout0_117ck1100 FIND v(dout0_117) AT=555.025n

.meas tran vdout0_118ck1100 FIND v(dout0_118) AT=555.025n

.meas tran vdout0_119ck1100 FIND v(dout0_119) AT=555.025n

.meas tran vdout0_120ck1100 FIND v(dout0_120) AT=555.025n

.meas tran vdout0_121ck1100 FIND v(dout0_121) AT=555.025n

.meas tran vdout0_122ck1100 FIND v(dout0_122) AT=555.025n

.meas tran vdout0_123ck1100 FIND v(dout0_123) AT=555.025n

.meas tran vdout0_124ck1100 FIND v(dout0_124) AT=555.025n

.meas tran vdout0_125ck1100 FIND v(dout0_125) AT=555.025n

.meas tran vdout0_126ck1100 FIND v(dout0_126) AT=555.025n

.meas tran vdout0_127ck1100 FIND v(dout0_127) AT=555.025n

.meas tran vdout0_0ck1110 FIND v(dout0_0) AT=560.025n

.meas tran vdout0_1ck1110 FIND v(dout0_1) AT=560.025n

.meas tran vdout0_2ck1110 FIND v(dout0_2) AT=560.025n

.meas tran vdout0_3ck1110 FIND v(dout0_3) AT=560.025n

.meas tran vdout0_4ck1110 FIND v(dout0_4) AT=560.025n

.meas tran vdout0_5ck1110 FIND v(dout0_5) AT=560.025n

.meas tran vdout0_6ck1110 FIND v(dout0_6) AT=560.025n

.meas tran vdout0_7ck1110 FIND v(dout0_7) AT=560.025n

.meas tran vdout0_8ck1110 FIND v(dout0_8) AT=560.025n

.meas tran vdout0_9ck1110 FIND v(dout0_9) AT=560.025n

.meas tran vdout0_10ck1110 FIND v(dout0_10) AT=560.025n

.meas tran vdout0_11ck1110 FIND v(dout0_11) AT=560.025n

.meas tran vdout0_12ck1110 FIND v(dout0_12) AT=560.025n

.meas tran vdout0_13ck1110 FIND v(dout0_13) AT=560.025n

.meas tran vdout0_14ck1110 FIND v(dout0_14) AT=560.025n

.meas tran vdout0_15ck1110 FIND v(dout0_15) AT=560.025n

.meas tran vdout0_16ck1110 FIND v(dout0_16) AT=560.025n

.meas tran vdout0_17ck1110 FIND v(dout0_17) AT=560.025n

.meas tran vdout0_18ck1110 FIND v(dout0_18) AT=560.025n

.meas tran vdout0_19ck1110 FIND v(dout0_19) AT=560.025n

.meas tran vdout0_20ck1110 FIND v(dout0_20) AT=560.025n

.meas tran vdout0_21ck1110 FIND v(dout0_21) AT=560.025n

.meas tran vdout0_22ck1110 FIND v(dout0_22) AT=560.025n

.meas tran vdout0_23ck1110 FIND v(dout0_23) AT=560.025n

.meas tran vdout0_24ck1110 FIND v(dout0_24) AT=560.025n

.meas tran vdout0_25ck1110 FIND v(dout0_25) AT=560.025n

.meas tran vdout0_26ck1110 FIND v(dout0_26) AT=560.025n

.meas tran vdout0_27ck1110 FIND v(dout0_27) AT=560.025n

.meas tran vdout0_28ck1110 FIND v(dout0_28) AT=560.025n

.meas tran vdout0_29ck1110 FIND v(dout0_29) AT=560.025n

.meas tran vdout0_30ck1110 FIND v(dout0_30) AT=560.025n

.meas tran vdout0_31ck1110 FIND v(dout0_31) AT=560.025n

.meas tran vdout0_32ck1110 FIND v(dout0_32) AT=560.025n

.meas tran vdout0_33ck1110 FIND v(dout0_33) AT=560.025n

.meas tran vdout0_34ck1110 FIND v(dout0_34) AT=560.025n

.meas tran vdout0_35ck1110 FIND v(dout0_35) AT=560.025n

.meas tran vdout0_36ck1110 FIND v(dout0_36) AT=560.025n

.meas tran vdout0_37ck1110 FIND v(dout0_37) AT=560.025n

.meas tran vdout0_38ck1110 FIND v(dout0_38) AT=560.025n

.meas tran vdout0_39ck1110 FIND v(dout0_39) AT=560.025n

.meas tran vdout0_40ck1110 FIND v(dout0_40) AT=560.025n

.meas tran vdout0_41ck1110 FIND v(dout0_41) AT=560.025n

.meas tran vdout0_42ck1110 FIND v(dout0_42) AT=560.025n

.meas tran vdout0_43ck1110 FIND v(dout0_43) AT=560.025n

.meas tran vdout0_44ck1110 FIND v(dout0_44) AT=560.025n

.meas tran vdout0_45ck1110 FIND v(dout0_45) AT=560.025n

.meas tran vdout0_46ck1110 FIND v(dout0_46) AT=560.025n

.meas tran vdout0_47ck1110 FIND v(dout0_47) AT=560.025n

.meas tran vdout0_48ck1110 FIND v(dout0_48) AT=560.025n

.meas tran vdout0_49ck1110 FIND v(dout0_49) AT=560.025n

.meas tran vdout0_50ck1110 FIND v(dout0_50) AT=560.025n

.meas tran vdout0_51ck1110 FIND v(dout0_51) AT=560.025n

.meas tran vdout0_52ck1110 FIND v(dout0_52) AT=560.025n

.meas tran vdout0_53ck1110 FIND v(dout0_53) AT=560.025n

.meas tran vdout0_54ck1110 FIND v(dout0_54) AT=560.025n

.meas tran vdout0_55ck1110 FIND v(dout0_55) AT=560.025n

.meas tran vdout0_56ck1110 FIND v(dout0_56) AT=560.025n

.meas tran vdout0_57ck1110 FIND v(dout0_57) AT=560.025n

.meas tran vdout0_58ck1110 FIND v(dout0_58) AT=560.025n

.meas tran vdout0_59ck1110 FIND v(dout0_59) AT=560.025n

.meas tran vdout0_60ck1110 FIND v(dout0_60) AT=560.025n

.meas tran vdout0_61ck1110 FIND v(dout0_61) AT=560.025n

.meas tran vdout0_62ck1110 FIND v(dout0_62) AT=560.025n

.meas tran vdout0_63ck1110 FIND v(dout0_63) AT=560.025n

.meas tran vdout0_64ck1110 FIND v(dout0_64) AT=560.025n

.meas tran vdout0_65ck1110 FIND v(dout0_65) AT=560.025n

.meas tran vdout0_66ck1110 FIND v(dout0_66) AT=560.025n

.meas tran vdout0_67ck1110 FIND v(dout0_67) AT=560.025n

.meas tran vdout0_68ck1110 FIND v(dout0_68) AT=560.025n

.meas tran vdout0_69ck1110 FIND v(dout0_69) AT=560.025n

.meas tran vdout0_70ck1110 FIND v(dout0_70) AT=560.025n

.meas tran vdout0_71ck1110 FIND v(dout0_71) AT=560.025n

.meas tran vdout0_72ck1110 FIND v(dout0_72) AT=560.025n

.meas tran vdout0_73ck1110 FIND v(dout0_73) AT=560.025n

.meas tran vdout0_74ck1110 FIND v(dout0_74) AT=560.025n

.meas tran vdout0_75ck1110 FIND v(dout0_75) AT=560.025n

.meas tran vdout0_76ck1110 FIND v(dout0_76) AT=560.025n

.meas tran vdout0_77ck1110 FIND v(dout0_77) AT=560.025n

.meas tran vdout0_78ck1110 FIND v(dout0_78) AT=560.025n

.meas tran vdout0_79ck1110 FIND v(dout0_79) AT=560.025n

.meas tran vdout0_80ck1110 FIND v(dout0_80) AT=560.025n

.meas tran vdout0_81ck1110 FIND v(dout0_81) AT=560.025n

.meas tran vdout0_82ck1110 FIND v(dout0_82) AT=560.025n

.meas tran vdout0_83ck1110 FIND v(dout0_83) AT=560.025n

.meas tran vdout0_84ck1110 FIND v(dout0_84) AT=560.025n

.meas tran vdout0_85ck1110 FIND v(dout0_85) AT=560.025n

.meas tran vdout0_86ck1110 FIND v(dout0_86) AT=560.025n

.meas tran vdout0_87ck1110 FIND v(dout0_87) AT=560.025n

.meas tran vdout0_88ck1110 FIND v(dout0_88) AT=560.025n

.meas tran vdout0_89ck1110 FIND v(dout0_89) AT=560.025n

.meas tran vdout0_90ck1110 FIND v(dout0_90) AT=560.025n

.meas tran vdout0_91ck1110 FIND v(dout0_91) AT=560.025n

.meas tran vdout0_92ck1110 FIND v(dout0_92) AT=560.025n

.meas tran vdout0_93ck1110 FIND v(dout0_93) AT=560.025n

.meas tran vdout0_94ck1110 FIND v(dout0_94) AT=560.025n

.meas tran vdout0_95ck1110 FIND v(dout0_95) AT=560.025n

.meas tran vdout0_96ck1110 FIND v(dout0_96) AT=560.025n

.meas tran vdout0_97ck1110 FIND v(dout0_97) AT=560.025n

.meas tran vdout0_98ck1110 FIND v(dout0_98) AT=560.025n

.meas tran vdout0_99ck1110 FIND v(dout0_99) AT=560.025n

.meas tran vdout0_100ck1110 FIND v(dout0_100) AT=560.025n

.meas tran vdout0_101ck1110 FIND v(dout0_101) AT=560.025n

.meas tran vdout0_102ck1110 FIND v(dout0_102) AT=560.025n

.meas tran vdout0_103ck1110 FIND v(dout0_103) AT=560.025n

.meas tran vdout0_104ck1110 FIND v(dout0_104) AT=560.025n

.meas tran vdout0_105ck1110 FIND v(dout0_105) AT=560.025n

.meas tran vdout0_106ck1110 FIND v(dout0_106) AT=560.025n

.meas tran vdout0_107ck1110 FIND v(dout0_107) AT=560.025n

.meas tran vdout0_108ck1110 FIND v(dout0_108) AT=560.025n

.meas tran vdout0_109ck1110 FIND v(dout0_109) AT=560.025n

.meas tran vdout0_110ck1110 FIND v(dout0_110) AT=560.025n

.meas tran vdout0_111ck1110 FIND v(dout0_111) AT=560.025n

.meas tran vdout0_112ck1110 FIND v(dout0_112) AT=560.025n

.meas tran vdout0_113ck1110 FIND v(dout0_113) AT=560.025n

.meas tran vdout0_114ck1110 FIND v(dout0_114) AT=560.025n

.meas tran vdout0_115ck1110 FIND v(dout0_115) AT=560.025n

.meas tran vdout0_116ck1110 FIND v(dout0_116) AT=560.025n

.meas tran vdout0_117ck1110 FIND v(dout0_117) AT=560.025n

.meas tran vdout0_118ck1110 FIND v(dout0_118) AT=560.025n

.meas tran vdout0_119ck1110 FIND v(dout0_119) AT=560.025n

.meas tran vdout0_120ck1110 FIND v(dout0_120) AT=560.025n

.meas tran vdout0_121ck1110 FIND v(dout0_121) AT=560.025n

.meas tran vdout0_122ck1110 FIND v(dout0_122) AT=560.025n

.meas tran vdout0_123ck1110 FIND v(dout0_123) AT=560.025n

.meas tran vdout0_124ck1110 FIND v(dout0_124) AT=560.025n

.meas tran vdout0_125ck1110 FIND v(dout0_125) AT=560.025n

.meas tran vdout0_126ck1110 FIND v(dout0_126) AT=560.025n

.meas tran vdout0_127ck1110 FIND v(dout0_127) AT=560.025n

.meas tran vdout0_0ck1130 FIND v(dout0_0) AT=570.025n

.meas tran vdout0_1ck1130 FIND v(dout0_1) AT=570.025n

.meas tran vdout0_2ck1130 FIND v(dout0_2) AT=570.025n

.meas tran vdout0_3ck1130 FIND v(dout0_3) AT=570.025n

.meas tran vdout0_4ck1130 FIND v(dout0_4) AT=570.025n

.meas tran vdout0_5ck1130 FIND v(dout0_5) AT=570.025n

.meas tran vdout0_6ck1130 FIND v(dout0_6) AT=570.025n

.meas tran vdout0_7ck1130 FIND v(dout0_7) AT=570.025n

.meas tran vdout0_8ck1130 FIND v(dout0_8) AT=570.025n

.meas tran vdout0_9ck1130 FIND v(dout0_9) AT=570.025n

.meas tran vdout0_10ck1130 FIND v(dout0_10) AT=570.025n

.meas tran vdout0_11ck1130 FIND v(dout0_11) AT=570.025n

.meas tran vdout0_12ck1130 FIND v(dout0_12) AT=570.025n

.meas tran vdout0_13ck1130 FIND v(dout0_13) AT=570.025n

.meas tran vdout0_14ck1130 FIND v(dout0_14) AT=570.025n

.meas tran vdout0_15ck1130 FIND v(dout0_15) AT=570.025n

.meas tran vdout0_16ck1130 FIND v(dout0_16) AT=570.025n

.meas tran vdout0_17ck1130 FIND v(dout0_17) AT=570.025n

.meas tran vdout0_18ck1130 FIND v(dout0_18) AT=570.025n

.meas tran vdout0_19ck1130 FIND v(dout0_19) AT=570.025n

.meas tran vdout0_20ck1130 FIND v(dout0_20) AT=570.025n

.meas tran vdout0_21ck1130 FIND v(dout0_21) AT=570.025n

.meas tran vdout0_22ck1130 FIND v(dout0_22) AT=570.025n

.meas tran vdout0_23ck1130 FIND v(dout0_23) AT=570.025n

.meas tran vdout0_24ck1130 FIND v(dout0_24) AT=570.025n

.meas tran vdout0_25ck1130 FIND v(dout0_25) AT=570.025n

.meas tran vdout0_26ck1130 FIND v(dout0_26) AT=570.025n

.meas tran vdout0_27ck1130 FIND v(dout0_27) AT=570.025n

.meas tran vdout0_28ck1130 FIND v(dout0_28) AT=570.025n

.meas tran vdout0_29ck1130 FIND v(dout0_29) AT=570.025n

.meas tran vdout0_30ck1130 FIND v(dout0_30) AT=570.025n

.meas tran vdout0_31ck1130 FIND v(dout0_31) AT=570.025n

.meas tran vdout0_32ck1130 FIND v(dout0_32) AT=570.025n

.meas tran vdout0_33ck1130 FIND v(dout0_33) AT=570.025n

.meas tran vdout0_34ck1130 FIND v(dout0_34) AT=570.025n

.meas tran vdout0_35ck1130 FIND v(dout0_35) AT=570.025n

.meas tran vdout0_36ck1130 FIND v(dout0_36) AT=570.025n

.meas tran vdout0_37ck1130 FIND v(dout0_37) AT=570.025n

.meas tran vdout0_38ck1130 FIND v(dout0_38) AT=570.025n

.meas tran vdout0_39ck1130 FIND v(dout0_39) AT=570.025n

.meas tran vdout0_40ck1130 FIND v(dout0_40) AT=570.025n

.meas tran vdout0_41ck1130 FIND v(dout0_41) AT=570.025n

.meas tran vdout0_42ck1130 FIND v(dout0_42) AT=570.025n

.meas tran vdout0_43ck1130 FIND v(dout0_43) AT=570.025n

.meas tran vdout0_44ck1130 FIND v(dout0_44) AT=570.025n

.meas tran vdout0_45ck1130 FIND v(dout0_45) AT=570.025n

.meas tran vdout0_46ck1130 FIND v(dout0_46) AT=570.025n

.meas tran vdout0_47ck1130 FIND v(dout0_47) AT=570.025n

.meas tran vdout0_48ck1130 FIND v(dout0_48) AT=570.025n

.meas tran vdout0_49ck1130 FIND v(dout0_49) AT=570.025n

.meas tran vdout0_50ck1130 FIND v(dout0_50) AT=570.025n

.meas tran vdout0_51ck1130 FIND v(dout0_51) AT=570.025n

.meas tran vdout0_52ck1130 FIND v(dout0_52) AT=570.025n

.meas tran vdout0_53ck1130 FIND v(dout0_53) AT=570.025n

.meas tran vdout0_54ck1130 FIND v(dout0_54) AT=570.025n

.meas tran vdout0_55ck1130 FIND v(dout0_55) AT=570.025n

.meas tran vdout0_56ck1130 FIND v(dout0_56) AT=570.025n

.meas tran vdout0_57ck1130 FIND v(dout0_57) AT=570.025n

.meas tran vdout0_58ck1130 FIND v(dout0_58) AT=570.025n

.meas tran vdout0_59ck1130 FIND v(dout0_59) AT=570.025n

.meas tran vdout0_60ck1130 FIND v(dout0_60) AT=570.025n

.meas tran vdout0_61ck1130 FIND v(dout0_61) AT=570.025n

.meas tran vdout0_62ck1130 FIND v(dout0_62) AT=570.025n

.meas tran vdout0_63ck1130 FIND v(dout0_63) AT=570.025n

.meas tran vdout0_64ck1130 FIND v(dout0_64) AT=570.025n

.meas tran vdout0_65ck1130 FIND v(dout0_65) AT=570.025n

.meas tran vdout0_66ck1130 FIND v(dout0_66) AT=570.025n

.meas tran vdout0_67ck1130 FIND v(dout0_67) AT=570.025n

.meas tran vdout0_68ck1130 FIND v(dout0_68) AT=570.025n

.meas tran vdout0_69ck1130 FIND v(dout0_69) AT=570.025n

.meas tran vdout0_70ck1130 FIND v(dout0_70) AT=570.025n

.meas tran vdout0_71ck1130 FIND v(dout0_71) AT=570.025n

.meas tran vdout0_72ck1130 FIND v(dout0_72) AT=570.025n

.meas tran vdout0_73ck1130 FIND v(dout0_73) AT=570.025n

.meas tran vdout0_74ck1130 FIND v(dout0_74) AT=570.025n

.meas tran vdout0_75ck1130 FIND v(dout0_75) AT=570.025n

.meas tran vdout0_76ck1130 FIND v(dout0_76) AT=570.025n

.meas tran vdout0_77ck1130 FIND v(dout0_77) AT=570.025n

.meas tran vdout0_78ck1130 FIND v(dout0_78) AT=570.025n

.meas tran vdout0_79ck1130 FIND v(dout0_79) AT=570.025n

.meas tran vdout0_80ck1130 FIND v(dout0_80) AT=570.025n

.meas tran vdout0_81ck1130 FIND v(dout0_81) AT=570.025n

.meas tran vdout0_82ck1130 FIND v(dout0_82) AT=570.025n

.meas tran vdout0_83ck1130 FIND v(dout0_83) AT=570.025n

.meas tran vdout0_84ck1130 FIND v(dout0_84) AT=570.025n

.meas tran vdout0_85ck1130 FIND v(dout0_85) AT=570.025n

.meas tran vdout0_86ck1130 FIND v(dout0_86) AT=570.025n

.meas tran vdout0_87ck1130 FIND v(dout0_87) AT=570.025n

.meas tran vdout0_88ck1130 FIND v(dout0_88) AT=570.025n

.meas tran vdout0_89ck1130 FIND v(dout0_89) AT=570.025n

.meas tran vdout0_90ck1130 FIND v(dout0_90) AT=570.025n

.meas tran vdout0_91ck1130 FIND v(dout0_91) AT=570.025n

.meas tran vdout0_92ck1130 FIND v(dout0_92) AT=570.025n

.meas tran vdout0_93ck1130 FIND v(dout0_93) AT=570.025n

.meas tran vdout0_94ck1130 FIND v(dout0_94) AT=570.025n

.meas tran vdout0_95ck1130 FIND v(dout0_95) AT=570.025n

.meas tran vdout0_96ck1130 FIND v(dout0_96) AT=570.025n

.meas tran vdout0_97ck1130 FIND v(dout0_97) AT=570.025n

.meas tran vdout0_98ck1130 FIND v(dout0_98) AT=570.025n

.meas tran vdout0_99ck1130 FIND v(dout0_99) AT=570.025n

.meas tran vdout0_100ck1130 FIND v(dout0_100) AT=570.025n

.meas tran vdout0_101ck1130 FIND v(dout0_101) AT=570.025n

.meas tran vdout0_102ck1130 FIND v(dout0_102) AT=570.025n

.meas tran vdout0_103ck1130 FIND v(dout0_103) AT=570.025n

.meas tran vdout0_104ck1130 FIND v(dout0_104) AT=570.025n

.meas tran vdout0_105ck1130 FIND v(dout0_105) AT=570.025n

.meas tran vdout0_106ck1130 FIND v(dout0_106) AT=570.025n

.meas tran vdout0_107ck1130 FIND v(dout0_107) AT=570.025n

.meas tran vdout0_108ck1130 FIND v(dout0_108) AT=570.025n

.meas tran vdout0_109ck1130 FIND v(dout0_109) AT=570.025n

.meas tran vdout0_110ck1130 FIND v(dout0_110) AT=570.025n

.meas tran vdout0_111ck1130 FIND v(dout0_111) AT=570.025n

.meas tran vdout0_112ck1130 FIND v(dout0_112) AT=570.025n

.meas tran vdout0_113ck1130 FIND v(dout0_113) AT=570.025n

.meas tran vdout0_114ck1130 FIND v(dout0_114) AT=570.025n

.meas tran vdout0_115ck1130 FIND v(dout0_115) AT=570.025n

.meas tran vdout0_116ck1130 FIND v(dout0_116) AT=570.025n

.meas tran vdout0_117ck1130 FIND v(dout0_117) AT=570.025n

.meas tran vdout0_118ck1130 FIND v(dout0_118) AT=570.025n

.meas tran vdout0_119ck1130 FIND v(dout0_119) AT=570.025n

.meas tran vdout0_120ck1130 FIND v(dout0_120) AT=570.025n

.meas tran vdout0_121ck1130 FIND v(dout0_121) AT=570.025n

.meas tran vdout0_122ck1130 FIND v(dout0_122) AT=570.025n

.meas tran vdout0_123ck1130 FIND v(dout0_123) AT=570.025n

.meas tran vdout0_124ck1130 FIND v(dout0_124) AT=570.025n

.meas tran vdout0_125ck1130 FIND v(dout0_125) AT=570.025n

.meas tran vdout0_126ck1130 FIND v(dout0_126) AT=570.025n

.meas tran vdout0_127ck1130 FIND v(dout0_127) AT=570.025n

.meas tran vdout0_0ck1150 FIND v(dout0_0) AT=580.025n

.meas tran vdout0_1ck1150 FIND v(dout0_1) AT=580.025n

.meas tran vdout0_2ck1150 FIND v(dout0_2) AT=580.025n

.meas tran vdout0_3ck1150 FIND v(dout0_3) AT=580.025n

.meas tran vdout0_4ck1150 FIND v(dout0_4) AT=580.025n

.meas tran vdout0_5ck1150 FIND v(dout0_5) AT=580.025n

.meas tran vdout0_6ck1150 FIND v(dout0_6) AT=580.025n

.meas tran vdout0_7ck1150 FIND v(dout0_7) AT=580.025n

.meas tran vdout0_8ck1150 FIND v(dout0_8) AT=580.025n

.meas tran vdout0_9ck1150 FIND v(dout0_9) AT=580.025n

.meas tran vdout0_10ck1150 FIND v(dout0_10) AT=580.025n

.meas tran vdout0_11ck1150 FIND v(dout0_11) AT=580.025n

.meas tran vdout0_12ck1150 FIND v(dout0_12) AT=580.025n

.meas tran vdout0_13ck1150 FIND v(dout0_13) AT=580.025n

.meas tran vdout0_14ck1150 FIND v(dout0_14) AT=580.025n

.meas tran vdout0_15ck1150 FIND v(dout0_15) AT=580.025n

.meas tran vdout0_16ck1150 FIND v(dout0_16) AT=580.025n

.meas tran vdout0_17ck1150 FIND v(dout0_17) AT=580.025n

.meas tran vdout0_18ck1150 FIND v(dout0_18) AT=580.025n

.meas tran vdout0_19ck1150 FIND v(dout0_19) AT=580.025n

.meas tran vdout0_20ck1150 FIND v(dout0_20) AT=580.025n

.meas tran vdout0_21ck1150 FIND v(dout0_21) AT=580.025n

.meas tran vdout0_22ck1150 FIND v(dout0_22) AT=580.025n

.meas tran vdout0_23ck1150 FIND v(dout0_23) AT=580.025n

.meas tran vdout0_24ck1150 FIND v(dout0_24) AT=580.025n

.meas tran vdout0_25ck1150 FIND v(dout0_25) AT=580.025n

.meas tran vdout0_26ck1150 FIND v(dout0_26) AT=580.025n

.meas tran vdout0_27ck1150 FIND v(dout0_27) AT=580.025n

.meas tran vdout0_28ck1150 FIND v(dout0_28) AT=580.025n

.meas tran vdout0_29ck1150 FIND v(dout0_29) AT=580.025n

.meas tran vdout0_30ck1150 FIND v(dout0_30) AT=580.025n

.meas tran vdout0_31ck1150 FIND v(dout0_31) AT=580.025n

.meas tran vdout0_32ck1150 FIND v(dout0_32) AT=580.025n

.meas tran vdout0_33ck1150 FIND v(dout0_33) AT=580.025n

.meas tran vdout0_34ck1150 FIND v(dout0_34) AT=580.025n

.meas tran vdout0_35ck1150 FIND v(dout0_35) AT=580.025n

.meas tran vdout0_36ck1150 FIND v(dout0_36) AT=580.025n

.meas tran vdout0_37ck1150 FIND v(dout0_37) AT=580.025n

.meas tran vdout0_38ck1150 FIND v(dout0_38) AT=580.025n

.meas tran vdout0_39ck1150 FIND v(dout0_39) AT=580.025n

.meas tran vdout0_40ck1150 FIND v(dout0_40) AT=580.025n

.meas tran vdout0_41ck1150 FIND v(dout0_41) AT=580.025n

.meas tran vdout0_42ck1150 FIND v(dout0_42) AT=580.025n

.meas tran vdout0_43ck1150 FIND v(dout0_43) AT=580.025n

.meas tran vdout0_44ck1150 FIND v(dout0_44) AT=580.025n

.meas tran vdout0_45ck1150 FIND v(dout0_45) AT=580.025n

.meas tran vdout0_46ck1150 FIND v(dout0_46) AT=580.025n

.meas tran vdout0_47ck1150 FIND v(dout0_47) AT=580.025n

.meas tran vdout0_48ck1150 FIND v(dout0_48) AT=580.025n

.meas tran vdout0_49ck1150 FIND v(dout0_49) AT=580.025n

.meas tran vdout0_50ck1150 FIND v(dout0_50) AT=580.025n

.meas tran vdout0_51ck1150 FIND v(dout0_51) AT=580.025n

.meas tran vdout0_52ck1150 FIND v(dout0_52) AT=580.025n

.meas tran vdout0_53ck1150 FIND v(dout0_53) AT=580.025n

.meas tran vdout0_54ck1150 FIND v(dout0_54) AT=580.025n

.meas tran vdout0_55ck1150 FIND v(dout0_55) AT=580.025n

.meas tran vdout0_56ck1150 FIND v(dout0_56) AT=580.025n

.meas tran vdout0_57ck1150 FIND v(dout0_57) AT=580.025n

.meas tran vdout0_58ck1150 FIND v(dout0_58) AT=580.025n

.meas tran vdout0_59ck1150 FIND v(dout0_59) AT=580.025n

.meas tran vdout0_60ck1150 FIND v(dout0_60) AT=580.025n

.meas tran vdout0_61ck1150 FIND v(dout0_61) AT=580.025n

.meas tran vdout0_62ck1150 FIND v(dout0_62) AT=580.025n

.meas tran vdout0_63ck1150 FIND v(dout0_63) AT=580.025n

.meas tran vdout0_64ck1150 FIND v(dout0_64) AT=580.025n

.meas tran vdout0_65ck1150 FIND v(dout0_65) AT=580.025n

.meas tran vdout0_66ck1150 FIND v(dout0_66) AT=580.025n

.meas tran vdout0_67ck1150 FIND v(dout0_67) AT=580.025n

.meas tran vdout0_68ck1150 FIND v(dout0_68) AT=580.025n

.meas tran vdout0_69ck1150 FIND v(dout0_69) AT=580.025n

.meas tran vdout0_70ck1150 FIND v(dout0_70) AT=580.025n

.meas tran vdout0_71ck1150 FIND v(dout0_71) AT=580.025n

.meas tran vdout0_72ck1150 FIND v(dout0_72) AT=580.025n

.meas tran vdout0_73ck1150 FIND v(dout0_73) AT=580.025n

.meas tran vdout0_74ck1150 FIND v(dout0_74) AT=580.025n

.meas tran vdout0_75ck1150 FIND v(dout0_75) AT=580.025n

.meas tran vdout0_76ck1150 FIND v(dout0_76) AT=580.025n

.meas tran vdout0_77ck1150 FIND v(dout0_77) AT=580.025n

.meas tran vdout0_78ck1150 FIND v(dout0_78) AT=580.025n

.meas tran vdout0_79ck1150 FIND v(dout0_79) AT=580.025n

.meas tran vdout0_80ck1150 FIND v(dout0_80) AT=580.025n

.meas tran vdout0_81ck1150 FIND v(dout0_81) AT=580.025n

.meas tran vdout0_82ck1150 FIND v(dout0_82) AT=580.025n

.meas tran vdout0_83ck1150 FIND v(dout0_83) AT=580.025n

.meas tran vdout0_84ck1150 FIND v(dout0_84) AT=580.025n

.meas tran vdout0_85ck1150 FIND v(dout0_85) AT=580.025n

.meas tran vdout0_86ck1150 FIND v(dout0_86) AT=580.025n

.meas tran vdout0_87ck1150 FIND v(dout0_87) AT=580.025n

.meas tran vdout0_88ck1150 FIND v(dout0_88) AT=580.025n

.meas tran vdout0_89ck1150 FIND v(dout0_89) AT=580.025n

.meas tran vdout0_90ck1150 FIND v(dout0_90) AT=580.025n

.meas tran vdout0_91ck1150 FIND v(dout0_91) AT=580.025n

.meas tran vdout0_92ck1150 FIND v(dout0_92) AT=580.025n

.meas tran vdout0_93ck1150 FIND v(dout0_93) AT=580.025n

.meas tran vdout0_94ck1150 FIND v(dout0_94) AT=580.025n

.meas tran vdout0_95ck1150 FIND v(dout0_95) AT=580.025n

.meas tran vdout0_96ck1150 FIND v(dout0_96) AT=580.025n

.meas tran vdout0_97ck1150 FIND v(dout0_97) AT=580.025n

.meas tran vdout0_98ck1150 FIND v(dout0_98) AT=580.025n

.meas tran vdout0_99ck1150 FIND v(dout0_99) AT=580.025n

.meas tran vdout0_100ck1150 FIND v(dout0_100) AT=580.025n

.meas tran vdout0_101ck1150 FIND v(dout0_101) AT=580.025n

.meas tran vdout0_102ck1150 FIND v(dout0_102) AT=580.025n

.meas tran vdout0_103ck1150 FIND v(dout0_103) AT=580.025n

.meas tran vdout0_104ck1150 FIND v(dout0_104) AT=580.025n

.meas tran vdout0_105ck1150 FIND v(dout0_105) AT=580.025n

.meas tran vdout0_106ck1150 FIND v(dout0_106) AT=580.025n

.meas tran vdout0_107ck1150 FIND v(dout0_107) AT=580.025n

.meas tran vdout0_108ck1150 FIND v(dout0_108) AT=580.025n

.meas tran vdout0_109ck1150 FIND v(dout0_109) AT=580.025n

.meas tran vdout0_110ck1150 FIND v(dout0_110) AT=580.025n

.meas tran vdout0_111ck1150 FIND v(dout0_111) AT=580.025n

.meas tran vdout0_112ck1150 FIND v(dout0_112) AT=580.025n

.meas tran vdout0_113ck1150 FIND v(dout0_113) AT=580.025n

.meas tran vdout0_114ck1150 FIND v(dout0_114) AT=580.025n

.meas tran vdout0_115ck1150 FIND v(dout0_115) AT=580.025n

.meas tran vdout0_116ck1150 FIND v(dout0_116) AT=580.025n

.meas tran vdout0_117ck1150 FIND v(dout0_117) AT=580.025n

.meas tran vdout0_118ck1150 FIND v(dout0_118) AT=580.025n

.meas tran vdout0_119ck1150 FIND v(dout0_119) AT=580.025n

.meas tran vdout0_120ck1150 FIND v(dout0_120) AT=580.025n

.meas tran vdout0_121ck1150 FIND v(dout0_121) AT=580.025n

.meas tran vdout0_122ck1150 FIND v(dout0_122) AT=580.025n

.meas tran vdout0_123ck1150 FIND v(dout0_123) AT=580.025n

.meas tran vdout0_124ck1150 FIND v(dout0_124) AT=580.025n

.meas tran vdout0_125ck1150 FIND v(dout0_125) AT=580.025n

.meas tran vdout0_126ck1150 FIND v(dout0_126) AT=580.025n

.meas tran vdout0_127ck1150 FIND v(dout0_127) AT=580.025n

.meas tran vdout0_0ck1160 FIND v(dout0_0) AT=585.025n

.meas tran vdout0_1ck1160 FIND v(dout0_1) AT=585.025n

.meas tran vdout0_2ck1160 FIND v(dout0_2) AT=585.025n

.meas tran vdout0_3ck1160 FIND v(dout0_3) AT=585.025n

.meas tran vdout0_4ck1160 FIND v(dout0_4) AT=585.025n

.meas tran vdout0_5ck1160 FIND v(dout0_5) AT=585.025n

.meas tran vdout0_6ck1160 FIND v(dout0_6) AT=585.025n

.meas tran vdout0_7ck1160 FIND v(dout0_7) AT=585.025n

.meas tran vdout0_8ck1160 FIND v(dout0_8) AT=585.025n

.meas tran vdout0_9ck1160 FIND v(dout0_9) AT=585.025n

.meas tran vdout0_10ck1160 FIND v(dout0_10) AT=585.025n

.meas tran vdout0_11ck1160 FIND v(dout0_11) AT=585.025n

.meas tran vdout0_12ck1160 FIND v(dout0_12) AT=585.025n

.meas tran vdout0_13ck1160 FIND v(dout0_13) AT=585.025n

.meas tran vdout0_14ck1160 FIND v(dout0_14) AT=585.025n

.meas tran vdout0_15ck1160 FIND v(dout0_15) AT=585.025n

.meas tran vdout0_16ck1160 FIND v(dout0_16) AT=585.025n

.meas tran vdout0_17ck1160 FIND v(dout0_17) AT=585.025n

.meas tran vdout0_18ck1160 FIND v(dout0_18) AT=585.025n

.meas tran vdout0_19ck1160 FIND v(dout0_19) AT=585.025n

.meas tran vdout0_20ck1160 FIND v(dout0_20) AT=585.025n

.meas tran vdout0_21ck1160 FIND v(dout0_21) AT=585.025n

.meas tran vdout0_22ck1160 FIND v(dout0_22) AT=585.025n

.meas tran vdout0_23ck1160 FIND v(dout0_23) AT=585.025n

.meas tran vdout0_24ck1160 FIND v(dout0_24) AT=585.025n

.meas tran vdout0_25ck1160 FIND v(dout0_25) AT=585.025n

.meas tran vdout0_26ck1160 FIND v(dout0_26) AT=585.025n

.meas tran vdout0_27ck1160 FIND v(dout0_27) AT=585.025n

.meas tran vdout0_28ck1160 FIND v(dout0_28) AT=585.025n

.meas tran vdout0_29ck1160 FIND v(dout0_29) AT=585.025n

.meas tran vdout0_30ck1160 FIND v(dout0_30) AT=585.025n

.meas tran vdout0_31ck1160 FIND v(dout0_31) AT=585.025n

.meas tran vdout0_32ck1160 FIND v(dout0_32) AT=585.025n

.meas tran vdout0_33ck1160 FIND v(dout0_33) AT=585.025n

.meas tran vdout0_34ck1160 FIND v(dout0_34) AT=585.025n

.meas tran vdout0_35ck1160 FIND v(dout0_35) AT=585.025n

.meas tran vdout0_36ck1160 FIND v(dout0_36) AT=585.025n

.meas tran vdout0_37ck1160 FIND v(dout0_37) AT=585.025n

.meas tran vdout0_38ck1160 FIND v(dout0_38) AT=585.025n

.meas tran vdout0_39ck1160 FIND v(dout0_39) AT=585.025n

.meas tran vdout0_40ck1160 FIND v(dout0_40) AT=585.025n

.meas tran vdout0_41ck1160 FIND v(dout0_41) AT=585.025n

.meas tran vdout0_42ck1160 FIND v(dout0_42) AT=585.025n

.meas tran vdout0_43ck1160 FIND v(dout0_43) AT=585.025n

.meas tran vdout0_44ck1160 FIND v(dout0_44) AT=585.025n

.meas tran vdout0_45ck1160 FIND v(dout0_45) AT=585.025n

.meas tran vdout0_46ck1160 FIND v(dout0_46) AT=585.025n

.meas tran vdout0_47ck1160 FIND v(dout0_47) AT=585.025n

.meas tran vdout0_48ck1160 FIND v(dout0_48) AT=585.025n

.meas tran vdout0_49ck1160 FIND v(dout0_49) AT=585.025n

.meas tran vdout0_50ck1160 FIND v(dout0_50) AT=585.025n

.meas tran vdout0_51ck1160 FIND v(dout0_51) AT=585.025n

.meas tran vdout0_52ck1160 FIND v(dout0_52) AT=585.025n

.meas tran vdout0_53ck1160 FIND v(dout0_53) AT=585.025n

.meas tran vdout0_54ck1160 FIND v(dout0_54) AT=585.025n

.meas tran vdout0_55ck1160 FIND v(dout0_55) AT=585.025n

.meas tran vdout0_56ck1160 FIND v(dout0_56) AT=585.025n

.meas tran vdout0_57ck1160 FIND v(dout0_57) AT=585.025n

.meas tran vdout0_58ck1160 FIND v(dout0_58) AT=585.025n

.meas tran vdout0_59ck1160 FIND v(dout0_59) AT=585.025n

.meas tran vdout0_60ck1160 FIND v(dout0_60) AT=585.025n

.meas tran vdout0_61ck1160 FIND v(dout0_61) AT=585.025n

.meas tran vdout0_62ck1160 FIND v(dout0_62) AT=585.025n

.meas tran vdout0_63ck1160 FIND v(dout0_63) AT=585.025n

.meas tran vdout0_64ck1160 FIND v(dout0_64) AT=585.025n

.meas tran vdout0_65ck1160 FIND v(dout0_65) AT=585.025n

.meas tran vdout0_66ck1160 FIND v(dout0_66) AT=585.025n

.meas tran vdout0_67ck1160 FIND v(dout0_67) AT=585.025n

.meas tran vdout0_68ck1160 FIND v(dout0_68) AT=585.025n

.meas tran vdout0_69ck1160 FIND v(dout0_69) AT=585.025n

.meas tran vdout0_70ck1160 FIND v(dout0_70) AT=585.025n

.meas tran vdout0_71ck1160 FIND v(dout0_71) AT=585.025n

.meas tran vdout0_72ck1160 FIND v(dout0_72) AT=585.025n

.meas tran vdout0_73ck1160 FIND v(dout0_73) AT=585.025n

.meas tran vdout0_74ck1160 FIND v(dout0_74) AT=585.025n

.meas tran vdout0_75ck1160 FIND v(dout0_75) AT=585.025n

.meas tran vdout0_76ck1160 FIND v(dout0_76) AT=585.025n

.meas tran vdout0_77ck1160 FIND v(dout0_77) AT=585.025n

.meas tran vdout0_78ck1160 FIND v(dout0_78) AT=585.025n

.meas tran vdout0_79ck1160 FIND v(dout0_79) AT=585.025n

.meas tran vdout0_80ck1160 FIND v(dout0_80) AT=585.025n

.meas tran vdout0_81ck1160 FIND v(dout0_81) AT=585.025n

.meas tran vdout0_82ck1160 FIND v(dout0_82) AT=585.025n

.meas tran vdout0_83ck1160 FIND v(dout0_83) AT=585.025n

.meas tran vdout0_84ck1160 FIND v(dout0_84) AT=585.025n

.meas tran vdout0_85ck1160 FIND v(dout0_85) AT=585.025n

.meas tran vdout0_86ck1160 FIND v(dout0_86) AT=585.025n

.meas tran vdout0_87ck1160 FIND v(dout0_87) AT=585.025n

.meas tran vdout0_88ck1160 FIND v(dout0_88) AT=585.025n

.meas tran vdout0_89ck1160 FIND v(dout0_89) AT=585.025n

.meas tran vdout0_90ck1160 FIND v(dout0_90) AT=585.025n

.meas tran vdout0_91ck1160 FIND v(dout0_91) AT=585.025n

.meas tran vdout0_92ck1160 FIND v(dout0_92) AT=585.025n

.meas tran vdout0_93ck1160 FIND v(dout0_93) AT=585.025n

.meas tran vdout0_94ck1160 FIND v(dout0_94) AT=585.025n

.meas tran vdout0_95ck1160 FIND v(dout0_95) AT=585.025n

.meas tran vdout0_96ck1160 FIND v(dout0_96) AT=585.025n

.meas tran vdout0_97ck1160 FIND v(dout0_97) AT=585.025n

.meas tran vdout0_98ck1160 FIND v(dout0_98) AT=585.025n

.meas tran vdout0_99ck1160 FIND v(dout0_99) AT=585.025n

.meas tran vdout0_100ck1160 FIND v(dout0_100) AT=585.025n

.meas tran vdout0_101ck1160 FIND v(dout0_101) AT=585.025n

.meas tran vdout0_102ck1160 FIND v(dout0_102) AT=585.025n

.meas tran vdout0_103ck1160 FIND v(dout0_103) AT=585.025n

.meas tran vdout0_104ck1160 FIND v(dout0_104) AT=585.025n

.meas tran vdout0_105ck1160 FIND v(dout0_105) AT=585.025n

.meas tran vdout0_106ck1160 FIND v(dout0_106) AT=585.025n

.meas tran vdout0_107ck1160 FIND v(dout0_107) AT=585.025n

.meas tran vdout0_108ck1160 FIND v(dout0_108) AT=585.025n

.meas tran vdout0_109ck1160 FIND v(dout0_109) AT=585.025n

.meas tran vdout0_110ck1160 FIND v(dout0_110) AT=585.025n

.meas tran vdout0_111ck1160 FIND v(dout0_111) AT=585.025n

.meas tran vdout0_112ck1160 FIND v(dout0_112) AT=585.025n

.meas tran vdout0_113ck1160 FIND v(dout0_113) AT=585.025n

.meas tran vdout0_114ck1160 FIND v(dout0_114) AT=585.025n

.meas tran vdout0_115ck1160 FIND v(dout0_115) AT=585.025n

.meas tran vdout0_116ck1160 FIND v(dout0_116) AT=585.025n

.meas tran vdout0_117ck1160 FIND v(dout0_117) AT=585.025n

.meas tran vdout0_118ck1160 FIND v(dout0_118) AT=585.025n

.meas tran vdout0_119ck1160 FIND v(dout0_119) AT=585.025n

.meas tran vdout0_120ck1160 FIND v(dout0_120) AT=585.025n

.meas tran vdout0_121ck1160 FIND v(dout0_121) AT=585.025n

.meas tran vdout0_122ck1160 FIND v(dout0_122) AT=585.025n

.meas tran vdout0_123ck1160 FIND v(dout0_123) AT=585.025n

.meas tran vdout0_124ck1160 FIND v(dout0_124) AT=585.025n

.meas tran vdout0_125ck1160 FIND v(dout0_125) AT=585.025n

.meas tran vdout0_126ck1160 FIND v(dout0_126) AT=585.025n

.meas tran vdout0_127ck1160 FIND v(dout0_127) AT=585.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_0ck1240 FIND v(dout0_0) AT=625.025n

.meas tran vdout0_1ck1240 FIND v(dout0_1) AT=625.025n

.meas tran vdout0_2ck1240 FIND v(dout0_2) AT=625.025n

.meas tran vdout0_3ck1240 FIND v(dout0_3) AT=625.025n

.meas tran vdout0_4ck1240 FIND v(dout0_4) AT=625.025n

.meas tran vdout0_5ck1240 FIND v(dout0_5) AT=625.025n

.meas tran vdout0_6ck1240 FIND v(dout0_6) AT=625.025n

.meas tran vdout0_7ck1240 FIND v(dout0_7) AT=625.025n

.meas tran vdout0_8ck1240 FIND v(dout0_8) AT=625.025n

.meas tran vdout0_9ck1240 FIND v(dout0_9) AT=625.025n

.meas tran vdout0_10ck1240 FIND v(dout0_10) AT=625.025n

.meas tran vdout0_11ck1240 FIND v(dout0_11) AT=625.025n

.meas tran vdout0_12ck1240 FIND v(dout0_12) AT=625.025n

.meas tran vdout0_13ck1240 FIND v(dout0_13) AT=625.025n

.meas tran vdout0_14ck1240 FIND v(dout0_14) AT=625.025n

.meas tran vdout0_15ck1240 FIND v(dout0_15) AT=625.025n

.meas tran vdout0_16ck1240 FIND v(dout0_16) AT=625.025n

.meas tran vdout0_17ck1240 FIND v(dout0_17) AT=625.025n

.meas tran vdout0_18ck1240 FIND v(dout0_18) AT=625.025n

.meas tran vdout0_19ck1240 FIND v(dout0_19) AT=625.025n

.meas tran vdout0_20ck1240 FIND v(dout0_20) AT=625.025n

.meas tran vdout0_21ck1240 FIND v(dout0_21) AT=625.025n

.meas tran vdout0_22ck1240 FIND v(dout0_22) AT=625.025n

.meas tran vdout0_23ck1240 FIND v(dout0_23) AT=625.025n

.meas tran vdout0_24ck1240 FIND v(dout0_24) AT=625.025n

.meas tran vdout0_25ck1240 FIND v(dout0_25) AT=625.025n

.meas tran vdout0_26ck1240 FIND v(dout0_26) AT=625.025n

.meas tran vdout0_27ck1240 FIND v(dout0_27) AT=625.025n

.meas tran vdout0_28ck1240 FIND v(dout0_28) AT=625.025n

.meas tran vdout0_29ck1240 FIND v(dout0_29) AT=625.025n

.meas tran vdout0_30ck1240 FIND v(dout0_30) AT=625.025n

.meas tran vdout0_31ck1240 FIND v(dout0_31) AT=625.025n

.meas tran vdout0_32ck1240 FIND v(dout0_32) AT=625.025n

.meas tran vdout0_33ck1240 FIND v(dout0_33) AT=625.025n

.meas tran vdout0_34ck1240 FIND v(dout0_34) AT=625.025n

.meas tran vdout0_35ck1240 FIND v(dout0_35) AT=625.025n

.meas tran vdout0_36ck1240 FIND v(dout0_36) AT=625.025n

.meas tran vdout0_37ck1240 FIND v(dout0_37) AT=625.025n

.meas tran vdout0_38ck1240 FIND v(dout0_38) AT=625.025n

.meas tran vdout0_39ck1240 FIND v(dout0_39) AT=625.025n

.meas tran vdout0_40ck1240 FIND v(dout0_40) AT=625.025n

.meas tran vdout0_41ck1240 FIND v(dout0_41) AT=625.025n

.meas tran vdout0_42ck1240 FIND v(dout0_42) AT=625.025n

.meas tran vdout0_43ck1240 FIND v(dout0_43) AT=625.025n

.meas tran vdout0_44ck1240 FIND v(dout0_44) AT=625.025n

.meas tran vdout0_45ck1240 FIND v(dout0_45) AT=625.025n

.meas tran vdout0_46ck1240 FIND v(dout0_46) AT=625.025n

.meas tran vdout0_47ck1240 FIND v(dout0_47) AT=625.025n

.meas tran vdout0_48ck1240 FIND v(dout0_48) AT=625.025n

.meas tran vdout0_49ck1240 FIND v(dout0_49) AT=625.025n

.meas tran vdout0_50ck1240 FIND v(dout0_50) AT=625.025n

.meas tran vdout0_51ck1240 FIND v(dout0_51) AT=625.025n

.meas tran vdout0_52ck1240 FIND v(dout0_52) AT=625.025n

.meas tran vdout0_53ck1240 FIND v(dout0_53) AT=625.025n

.meas tran vdout0_54ck1240 FIND v(dout0_54) AT=625.025n

.meas tran vdout0_55ck1240 FIND v(dout0_55) AT=625.025n

.meas tran vdout0_56ck1240 FIND v(dout0_56) AT=625.025n

.meas tran vdout0_57ck1240 FIND v(dout0_57) AT=625.025n

.meas tran vdout0_58ck1240 FIND v(dout0_58) AT=625.025n

.meas tran vdout0_59ck1240 FIND v(dout0_59) AT=625.025n

.meas tran vdout0_60ck1240 FIND v(dout0_60) AT=625.025n

.meas tran vdout0_61ck1240 FIND v(dout0_61) AT=625.025n

.meas tran vdout0_62ck1240 FIND v(dout0_62) AT=625.025n

.meas tran vdout0_63ck1240 FIND v(dout0_63) AT=625.025n

.meas tran vdout0_64ck1240 FIND v(dout0_64) AT=625.025n

.meas tran vdout0_65ck1240 FIND v(dout0_65) AT=625.025n

.meas tran vdout0_66ck1240 FIND v(dout0_66) AT=625.025n

.meas tran vdout0_67ck1240 FIND v(dout0_67) AT=625.025n

.meas tran vdout0_68ck1240 FIND v(dout0_68) AT=625.025n

.meas tran vdout0_69ck1240 FIND v(dout0_69) AT=625.025n

.meas tran vdout0_70ck1240 FIND v(dout0_70) AT=625.025n

.meas tran vdout0_71ck1240 FIND v(dout0_71) AT=625.025n

.meas tran vdout0_72ck1240 FIND v(dout0_72) AT=625.025n

.meas tran vdout0_73ck1240 FIND v(dout0_73) AT=625.025n

.meas tran vdout0_74ck1240 FIND v(dout0_74) AT=625.025n

.meas tran vdout0_75ck1240 FIND v(dout0_75) AT=625.025n

.meas tran vdout0_76ck1240 FIND v(dout0_76) AT=625.025n

.meas tran vdout0_77ck1240 FIND v(dout0_77) AT=625.025n

.meas tran vdout0_78ck1240 FIND v(dout0_78) AT=625.025n

.meas tran vdout0_79ck1240 FIND v(dout0_79) AT=625.025n

.meas tran vdout0_80ck1240 FIND v(dout0_80) AT=625.025n

.meas tran vdout0_81ck1240 FIND v(dout0_81) AT=625.025n

.meas tran vdout0_82ck1240 FIND v(dout0_82) AT=625.025n

.meas tran vdout0_83ck1240 FIND v(dout0_83) AT=625.025n

.meas tran vdout0_84ck1240 FIND v(dout0_84) AT=625.025n

.meas tran vdout0_85ck1240 FIND v(dout0_85) AT=625.025n

.meas tran vdout0_86ck1240 FIND v(dout0_86) AT=625.025n

.meas tran vdout0_87ck1240 FIND v(dout0_87) AT=625.025n

.meas tran vdout0_88ck1240 FIND v(dout0_88) AT=625.025n

.meas tran vdout0_89ck1240 FIND v(dout0_89) AT=625.025n

.meas tran vdout0_90ck1240 FIND v(dout0_90) AT=625.025n

.meas tran vdout0_91ck1240 FIND v(dout0_91) AT=625.025n

.meas tran vdout0_92ck1240 FIND v(dout0_92) AT=625.025n

.meas tran vdout0_93ck1240 FIND v(dout0_93) AT=625.025n

.meas tran vdout0_94ck1240 FIND v(dout0_94) AT=625.025n

.meas tran vdout0_95ck1240 FIND v(dout0_95) AT=625.025n

.meas tran vdout0_96ck1240 FIND v(dout0_96) AT=625.025n

.meas tran vdout0_97ck1240 FIND v(dout0_97) AT=625.025n

.meas tran vdout0_98ck1240 FIND v(dout0_98) AT=625.025n

.meas tran vdout0_99ck1240 FIND v(dout0_99) AT=625.025n

.meas tran vdout0_100ck1240 FIND v(dout0_100) AT=625.025n

.meas tran vdout0_101ck1240 FIND v(dout0_101) AT=625.025n

.meas tran vdout0_102ck1240 FIND v(dout0_102) AT=625.025n

.meas tran vdout0_103ck1240 FIND v(dout0_103) AT=625.025n

.meas tran vdout0_104ck1240 FIND v(dout0_104) AT=625.025n

.meas tran vdout0_105ck1240 FIND v(dout0_105) AT=625.025n

.meas tran vdout0_106ck1240 FIND v(dout0_106) AT=625.025n

.meas tran vdout0_107ck1240 FIND v(dout0_107) AT=625.025n

.meas tran vdout0_108ck1240 FIND v(dout0_108) AT=625.025n

.meas tran vdout0_109ck1240 FIND v(dout0_109) AT=625.025n

.meas tran vdout0_110ck1240 FIND v(dout0_110) AT=625.025n

.meas tran vdout0_111ck1240 FIND v(dout0_111) AT=625.025n

.meas tran vdout0_112ck1240 FIND v(dout0_112) AT=625.025n

.meas tran vdout0_113ck1240 FIND v(dout0_113) AT=625.025n

.meas tran vdout0_114ck1240 FIND v(dout0_114) AT=625.025n

.meas tran vdout0_115ck1240 FIND v(dout0_115) AT=625.025n

.meas tran vdout0_116ck1240 FIND v(dout0_116) AT=625.025n

.meas tran vdout0_117ck1240 FIND v(dout0_117) AT=625.025n

.meas tran vdout0_118ck1240 FIND v(dout0_118) AT=625.025n

.meas tran vdout0_119ck1240 FIND v(dout0_119) AT=625.025n

.meas tran vdout0_120ck1240 FIND v(dout0_120) AT=625.025n

.meas tran vdout0_121ck1240 FIND v(dout0_121) AT=625.025n

.meas tran vdout0_122ck1240 FIND v(dout0_122) AT=625.025n

.meas tran vdout0_123ck1240 FIND v(dout0_123) AT=625.025n

.meas tran vdout0_124ck1240 FIND v(dout0_124) AT=625.025n

.meas tran vdout0_125ck1240 FIND v(dout0_125) AT=625.025n

.meas tran vdout0_126ck1240 FIND v(dout0_126) AT=625.025n

.meas tran vdout0_127ck1240 FIND v(dout0_127) AT=625.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_0ck1350 FIND v(dout0_0) AT=680.025n

.meas tran vdout0_1ck1350 FIND v(dout0_1) AT=680.025n

.meas tran vdout0_2ck1350 FIND v(dout0_2) AT=680.025n

.meas tran vdout0_3ck1350 FIND v(dout0_3) AT=680.025n

.meas tran vdout0_4ck1350 FIND v(dout0_4) AT=680.025n

.meas tran vdout0_5ck1350 FIND v(dout0_5) AT=680.025n

.meas tran vdout0_6ck1350 FIND v(dout0_6) AT=680.025n

.meas tran vdout0_7ck1350 FIND v(dout0_7) AT=680.025n

.meas tran vdout0_8ck1350 FIND v(dout0_8) AT=680.025n

.meas tran vdout0_9ck1350 FIND v(dout0_9) AT=680.025n

.meas tran vdout0_10ck1350 FIND v(dout0_10) AT=680.025n

.meas tran vdout0_11ck1350 FIND v(dout0_11) AT=680.025n

.meas tran vdout0_12ck1350 FIND v(dout0_12) AT=680.025n

.meas tran vdout0_13ck1350 FIND v(dout0_13) AT=680.025n

.meas tran vdout0_14ck1350 FIND v(dout0_14) AT=680.025n

.meas tran vdout0_15ck1350 FIND v(dout0_15) AT=680.025n

.meas tran vdout0_16ck1350 FIND v(dout0_16) AT=680.025n

.meas tran vdout0_17ck1350 FIND v(dout0_17) AT=680.025n

.meas tran vdout0_18ck1350 FIND v(dout0_18) AT=680.025n

.meas tran vdout0_19ck1350 FIND v(dout0_19) AT=680.025n

.meas tran vdout0_20ck1350 FIND v(dout0_20) AT=680.025n

.meas tran vdout0_21ck1350 FIND v(dout0_21) AT=680.025n

.meas tran vdout0_22ck1350 FIND v(dout0_22) AT=680.025n

.meas tran vdout0_23ck1350 FIND v(dout0_23) AT=680.025n

.meas tran vdout0_24ck1350 FIND v(dout0_24) AT=680.025n

.meas tran vdout0_25ck1350 FIND v(dout0_25) AT=680.025n

.meas tran vdout0_26ck1350 FIND v(dout0_26) AT=680.025n

.meas tran vdout0_27ck1350 FIND v(dout0_27) AT=680.025n

.meas tran vdout0_28ck1350 FIND v(dout0_28) AT=680.025n

.meas tran vdout0_29ck1350 FIND v(dout0_29) AT=680.025n

.meas tran vdout0_30ck1350 FIND v(dout0_30) AT=680.025n

.meas tran vdout0_31ck1350 FIND v(dout0_31) AT=680.025n

.meas tran vdout0_32ck1350 FIND v(dout0_32) AT=680.025n

.meas tran vdout0_33ck1350 FIND v(dout0_33) AT=680.025n

.meas tran vdout0_34ck1350 FIND v(dout0_34) AT=680.025n

.meas tran vdout0_35ck1350 FIND v(dout0_35) AT=680.025n

.meas tran vdout0_36ck1350 FIND v(dout0_36) AT=680.025n

.meas tran vdout0_37ck1350 FIND v(dout0_37) AT=680.025n

.meas tran vdout0_38ck1350 FIND v(dout0_38) AT=680.025n

.meas tran vdout0_39ck1350 FIND v(dout0_39) AT=680.025n

.meas tran vdout0_40ck1350 FIND v(dout0_40) AT=680.025n

.meas tran vdout0_41ck1350 FIND v(dout0_41) AT=680.025n

.meas tran vdout0_42ck1350 FIND v(dout0_42) AT=680.025n

.meas tran vdout0_43ck1350 FIND v(dout0_43) AT=680.025n

.meas tran vdout0_44ck1350 FIND v(dout0_44) AT=680.025n

.meas tran vdout0_45ck1350 FIND v(dout0_45) AT=680.025n

.meas tran vdout0_46ck1350 FIND v(dout0_46) AT=680.025n

.meas tran vdout0_47ck1350 FIND v(dout0_47) AT=680.025n

.meas tran vdout0_48ck1350 FIND v(dout0_48) AT=680.025n

.meas tran vdout0_49ck1350 FIND v(dout0_49) AT=680.025n

.meas tran vdout0_50ck1350 FIND v(dout0_50) AT=680.025n

.meas tran vdout0_51ck1350 FIND v(dout0_51) AT=680.025n

.meas tran vdout0_52ck1350 FIND v(dout0_52) AT=680.025n

.meas tran vdout0_53ck1350 FIND v(dout0_53) AT=680.025n

.meas tran vdout0_54ck1350 FIND v(dout0_54) AT=680.025n

.meas tran vdout0_55ck1350 FIND v(dout0_55) AT=680.025n

.meas tran vdout0_56ck1350 FIND v(dout0_56) AT=680.025n

.meas tran vdout0_57ck1350 FIND v(dout0_57) AT=680.025n

.meas tran vdout0_58ck1350 FIND v(dout0_58) AT=680.025n

.meas tran vdout0_59ck1350 FIND v(dout0_59) AT=680.025n

.meas tran vdout0_60ck1350 FIND v(dout0_60) AT=680.025n

.meas tran vdout0_61ck1350 FIND v(dout0_61) AT=680.025n

.meas tran vdout0_62ck1350 FIND v(dout0_62) AT=680.025n

.meas tran vdout0_63ck1350 FIND v(dout0_63) AT=680.025n

.meas tran vdout0_64ck1350 FIND v(dout0_64) AT=680.025n

.meas tran vdout0_65ck1350 FIND v(dout0_65) AT=680.025n

.meas tran vdout0_66ck1350 FIND v(dout0_66) AT=680.025n

.meas tran vdout0_67ck1350 FIND v(dout0_67) AT=680.025n

.meas tran vdout0_68ck1350 FIND v(dout0_68) AT=680.025n

.meas tran vdout0_69ck1350 FIND v(dout0_69) AT=680.025n

.meas tran vdout0_70ck1350 FIND v(dout0_70) AT=680.025n

.meas tran vdout0_71ck1350 FIND v(dout0_71) AT=680.025n

.meas tran vdout0_72ck1350 FIND v(dout0_72) AT=680.025n

.meas tran vdout0_73ck1350 FIND v(dout0_73) AT=680.025n

.meas tran vdout0_74ck1350 FIND v(dout0_74) AT=680.025n

.meas tran vdout0_75ck1350 FIND v(dout0_75) AT=680.025n

.meas tran vdout0_76ck1350 FIND v(dout0_76) AT=680.025n

.meas tran vdout0_77ck1350 FIND v(dout0_77) AT=680.025n

.meas tran vdout0_78ck1350 FIND v(dout0_78) AT=680.025n

.meas tran vdout0_79ck1350 FIND v(dout0_79) AT=680.025n

.meas tran vdout0_80ck1350 FIND v(dout0_80) AT=680.025n

.meas tran vdout0_81ck1350 FIND v(dout0_81) AT=680.025n

.meas tran vdout0_82ck1350 FIND v(dout0_82) AT=680.025n

.meas tran vdout0_83ck1350 FIND v(dout0_83) AT=680.025n

.meas tran vdout0_84ck1350 FIND v(dout0_84) AT=680.025n

.meas tran vdout0_85ck1350 FIND v(dout0_85) AT=680.025n

.meas tran vdout0_86ck1350 FIND v(dout0_86) AT=680.025n

.meas tran vdout0_87ck1350 FIND v(dout0_87) AT=680.025n

.meas tran vdout0_88ck1350 FIND v(dout0_88) AT=680.025n

.meas tran vdout0_89ck1350 FIND v(dout0_89) AT=680.025n

.meas tran vdout0_90ck1350 FIND v(dout0_90) AT=680.025n

.meas tran vdout0_91ck1350 FIND v(dout0_91) AT=680.025n

.meas tran vdout0_92ck1350 FIND v(dout0_92) AT=680.025n

.meas tran vdout0_93ck1350 FIND v(dout0_93) AT=680.025n

.meas tran vdout0_94ck1350 FIND v(dout0_94) AT=680.025n

.meas tran vdout0_95ck1350 FIND v(dout0_95) AT=680.025n

.meas tran vdout0_96ck1350 FIND v(dout0_96) AT=680.025n

.meas tran vdout0_97ck1350 FIND v(dout0_97) AT=680.025n

.meas tran vdout0_98ck1350 FIND v(dout0_98) AT=680.025n

.meas tran vdout0_99ck1350 FIND v(dout0_99) AT=680.025n

.meas tran vdout0_100ck1350 FIND v(dout0_100) AT=680.025n

.meas tran vdout0_101ck1350 FIND v(dout0_101) AT=680.025n

.meas tran vdout0_102ck1350 FIND v(dout0_102) AT=680.025n

.meas tran vdout0_103ck1350 FIND v(dout0_103) AT=680.025n

.meas tran vdout0_104ck1350 FIND v(dout0_104) AT=680.025n

.meas tran vdout0_105ck1350 FIND v(dout0_105) AT=680.025n

.meas tran vdout0_106ck1350 FIND v(dout0_106) AT=680.025n

.meas tran vdout0_107ck1350 FIND v(dout0_107) AT=680.025n

.meas tran vdout0_108ck1350 FIND v(dout0_108) AT=680.025n

.meas tran vdout0_109ck1350 FIND v(dout0_109) AT=680.025n

.meas tran vdout0_110ck1350 FIND v(dout0_110) AT=680.025n

.meas tran vdout0_111ck1350 FIND v(dout0_111) AT=680.025n

.meas tran vdout0_112ck1350 FIND v(dout0_112) AT=680.025n

.meas tran vdout0_113ck1350 FIND v(dout0_113) AT=680.025n

.meas tran vdout0_114ck1350 FIND v(dout0_114) AT=680.025n

.meas tran vdout0_115ck1350 FIND v(dout0_115) AT=680.025n

.meas tran vdout0_116ck1350 FIND v(dout0_116) AT=680.025n

.meas tran vdout0_117ck1350 FIND v(dout0_117) AT=680.025n

.meas tran vdout0_118ck1350 FIND v(dout0_118) AT=680.025n

.meas tran vdout0_119ck1350 FIND v(dout0_119) AT=680.025n

.meas tran vdout0_120ck1350 FIND v(dout0_120) AT=680.025n

.meas tran vdout0_121ck1350 FIND v(dout0_121) AT=680.025n

.meas tran vdout0_122ck1350 FIND v(dout0_122) AT=680.025n

.meas tran vdout0_123ck1350 FIND v(dout0_123) AT=680.025n

.meas tran vdout0_124ck1350 FIND v(dout0_124) AT=680.025n

.meas tran vdout0_125ck1350 FIND v(dout0_125) AT=680.025n

.meas tran vdout0_126ck1350 FIND v(dout0_126) AT=680.025n

.meas tran vdout0_127ck1350 FIND v(dout0_127) AT=680.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_0ck1380 FIND v(dout0_0) AT=695.025n

.meas tran vdout0_1ck1380 FIND v(dout0_1) AT=695.025n

.meas tran vdout0_2ck1380 FIND v(dout0_2) AT=695.025n

.meas tran vdout0_3ck1380 FIND v(dout0_3) AT=695.025n

.meas tran vdout0_4ck1380 FIND v(dout0_4) AT=695.025n

.meas tran vdout0_5ck1380 FIND v(dout0_5) AT=695.025n

.meas tran vdout0_6ck1380 FIND v(dout0_6) AT=695.025n

.meas tran vdout0_7ck1380 FIND v(dout0_7) AT=695.025n

.meas tran vdout0_8ck1380 FIND v(dout0_8) AT=695.025n

.meas tran vdout0_9ck1380 FIND v(dout0_9) AT=695.025n

.meas tran vdout0_10ck1380 FIND v(dout0_10) AT=695.025n

.meas tran vdout0_11ck1380 FIND v(dout0_11) AT=695.025n

.meas tran vdout0_12ck1380 FIND v(dout0_12) AT=695.025n

.meas tran vdout0_13ck1380 FIND v(dout0_13) AT=695.025n

.meas tran vdout0_14ck1380 FIND v(dout0_14) AT=695.025n

.meas tran vdout0_15ck1380 FIND v(dout0_15) AT=695.025n

.meas tran vdout0_16ck1380 FIND v(dout0_16) AT=695.025n

.meas tran vdout0_17ck1380 FIND v(dout0_17) AT=695.025n

.meas tran vdout0_18ck1380 FIND v(dout0_18) AT=695.025n

.meas tran vdout0_19ck1380 FIND v(dout0_19) AT=695.025n

.meas tran vdout0_20ck1380 FIND v(dout0_20) AT=695.025n

.meas tran vdout0_21ck1380 FIND v(dout0_21) AT=695.025n

.meas tran vdout0_22ck1380 FIND v(dout0_22) AT=695.025n

.meas tran vdout0_23ck1380 FIND v(dout0_23) AT=695.025n

.meas tran vdout0_24ck1380 FIND v(dout0_24) AT=695.025n

.meas tran vdout0_25ck1380 FIND v(dout0_25) AT=695.025n

.meas tran vdout0_26ck1380 FIND v(dout0_26) AT=695.025n

.meas tran vdout0_27ck1380 FIND v(dout0_27) AT=695.025n

.meas tran vdout0_28ck1380 FIND v(dout0_28) AT=695.025n

.meas tran vdout0_29ck1380 FIND v(dout0_29) AT=695.025n

.meas tran vdout0_30ck1380 FIND v(dout0_30) AT=695.025n

.meas tran vdout0_31ck1380 FIND v(dout0_31) AT=695.025n

.meas tran vdout0_32ck1380 FIND v(dout0_32) AT=695.025n

.meas tran vdout0_33ck1380 FIND v(dout0_33) AT=695.025n

.meas tran vdout0_34ck1380 FIND v(dout0_34) AT=695.025n

.meas tran vdout0_35ck1380 FIND v(dout0_35) AT=695.025n

.meas tran vdout0_36ck1380 FIND v(dout0_36) AT=695.025n

.meas tran vdout0_37ck1380 FIND v(dout0_37) AT=695.025n

.meas tran vdout0_38ck1380 FIND v(dout0_38) AT=695.025n

.meas tran vdout0_39ck1380 FIND v(dout0_39) AT=695.025n

.meas tran vdout0_40ck1380 FIND v(dout0_40) AT=695.025n

.meas tran vdout0_41ck1380 FIND v(dout0_41) AT=695.025n

.meas tran vdout0_42ck1380 FIND v(dout0_42) AT=695.025n

.meas tran vdout0_43ck1380 FIND v(dout0_43) AT=695.025n

.meas tran vdout0_44ck1380 FIND v(dout0_44) AT=695.025n

.meas tran vdout0_45ck1380 FIND v(dout0_45) AT=695.025n

.meas tran vdout0_46ck1380 FIND v(dout0_46) AT=695.025n

.meas tran vdout0_47ck1380 FIND v(dout0_47) AT=695.025n

.meas tran vdout0_48ck1380 FIND v(dout0_48) AT=695.025n

.meas tran vdout0_49ck1380 FIND v(dout0_49) AT=695.025n

.meas tran vdout0_50ck1380 FIND v(dout0_50) AT=695.025n

.meas tran vdout0_51ck1380 FIND v(dout0_51) AT=695.025n

.meas tran vdout0_52ck1380 FIND v(dout0_52) AT=695.025n

.meas tran vdout0_53ck1380 FIND v(dout0_53) AT=695.025n

.meas tran vdout0_54ck1380 FIND v(dout0_54) AT=695.025n

.meas tran vdout0_55ck1380 FIND v(dout0_55) AT=695.025n

.meas tran vdout0_56ck1380 FIND v(dout0_56) AT=695.025n

.meas tran vdout0_57ck1380 FIND v(dout0_57) AT=695.025n

.meas tran vdout0_58ck1380 FIND v(dout0_58) AT=695.025n

.meas tran vdout0_59ck1380 FIND v(dout0_59) AT=695.025n

.meas tran vdout0_60ck1380 FIND v(dout0_60) AT=695.025n

.meas tran vdout0_61ck1380 FIND v(dout0_61) AT=695.025n

.meas tran vdout0_62ck1380 FIND v(dout0_62) AT=695.025n

.meas tran vdout0_63ck1380 FIND v(dout0_63) AT=695.025n

.meas tran vdout0_64ck1380 FIND v(dout0_64) AT=695.025n

.meas tran vdout0_65ck1380 FIND v(dout0_65) AT=695.025n

.meas tran vdout0_66ck1380 FIND v(dout0_66) AT=695.025n

.meas tran vdout0_67ck1380 FIND v(dout0_67) AT=695.025n

.meas tran vdout0_68ck1380 FIND v(dout0_68) AT=695.025n

.meas tran vdout0_69ck1380 FIND v(dout0_69) AT=695.025n

.meas tran vdout0_70ck1380 FIND v(dout0_70) AT=695.025n

.meas tran vdout0_71ck1380 FIND v(dout0_71) AT=695.025n

.meas tran vdout0_72ck1380 FIND v(dout0_72) AT=695.025n

.meas tran vdout0_73ck1380 FIND v(dout0_73) AT=695.025n

.meas tran vdout0_74ck1380 FIND v(dout0_74) AT=695.025n

.meas tran vdout0_75ck1380 FIND v(dout0_75) AT=695.025n

.meas tran vdout0_76ck1380 FIND v(dout0_76) AT=695.025n

.meas tran vdout0_77ck1380 FIND v(dout0_77) AT=695.025n

.meas tran vdout0_78ck1380 FIND v(dout0_78) AT=695.025n

.meas tran vdout0_79ck1380 FIND v(dout0_79) AT=695.025n

.meas tran vdout0_80ck1380 FIND v(dout0_80) AT=695.025n

.meas tran vdout0_81ck1380 FIND v(dout0_81) AT=695.025n

.meas tran vdout0_82ck1380 FIND v(dout0_82) AT=695.025n

.meas tran vdout0_83ck1380 FIND v(dout0_83) AT=695.025n

.meas tran vdout0_84ck1380 FIND v(dout0_84) AT=695.025n

.meas tran vdout0_85ck1380 FIND v(dout0_85) AT=695.025n

.meas tran vdout0_86ck1380 FIND v(dout0_86) AT=695.025n

.meas tran vdout0_87ck1380 FIND v(dout0_87) AT=695.025n

.meas tran vdout0_88ck1380 FIND v(dout0_88) AT=695.025n

.meas tran vdout0_89ck1380 FIND v(dout0_89) AT=695.025n

.meas tran vdout0_90ck1380 FIND v(dout0_90) AT=695.025n

.meas tran vdout0_91ck1380 FIND v(dout0_91) AT=695.025n

.meas tran vdout0_92ck1380 FIND v(dout0_92) AT=695.025n

.meas tran vdout0_93ck1380 FIND v(dout0_93) AT=695.025n

.meas tran vdout0_94ck1380 FIND v(dout0_94) AT=695.025n

.meas tran vdout0_95ck1380 FIND v(dout0_95) AT=695.025n

.meas tran vdout0_96ck1380 FIND v(dout0_96) AT=695.025n

.meas tran vdout0_97ck1380 FIND v(dout0_97) AT=695.025n

.meas tran vdout0_98ck1380 FIND v(dout0_98) AT=695.025n

.meas tran vdout0_99ck1380 FIND v(dout0_99) AT=695.025n

.meas tran vdout0_100ck1380 FIND v(dout0_100) AT=695.025n

.meas tran vdout0_101ck1380 FIND v(dout0_101) AT=695.025n

.meas tran vdout0_102ck1380 FIND v(dout0_102) AT=695.025n

.meas tran vdout0_103ck1380 FIND v(dout0_103) AT=695.025n

.meas tran vdout0_104ck1380 FIND v(dout0_104) AT=695.025n

.meas tran vdout0_105ck1380 FIND v(dout0_105) AT=695.025n

.meas tran vdout0_106ck1380 FIND v(dout0_106) AT=695.025n

.meas tran vdout0_107ck1380 FIND v(dout0_107) AT=695.025n

.meas tran vdout0_108ck1380 FIND v(dout0_108) AT=695.025n

.meas tran vdout0_109ck1380 FIND v(dout0_109) AT=695.025n

.meas tran vdout0_110ck1380 FIND v(dout0_110) AT=695.025n

.meas tran vdout0_111ck1380 FIND v(dout0_111) AT=695.025n

.meas tran vdout0_112ck1380 FIND v(dout0_112) AT=695.025n

.meas tran vdout0_113ck1380 FIND v(dout0_113) AT=695.025n

.meas tran vdout0_114ck1380 FIND v(dout0_114) AT=695.025n

.meas tran vdout0_115ck1380 FIND v(dout0_115) AT=695.025n

.meas tran vdout0_116ck1380 FIND v(dout0_116) AT=695.025n

.meas tran vdout0_117ck1380 FIND v(dout0_117) AT=695.025n

.meas tran vdout0_118ck1380 FIND v(dout0_118) AT=695.025n

.meas tran vdout0_119ck1380 FIND v(dout0_119) AT=695.025n

.meas tran vdout0_120ck1380 FIND v(dout0_120) AT=695.025n

.meas tran vdout0_121ck1380 FIND v(dout0_121) AT=695.025n

.meas tran vdout0_122ck1380 FIND v(dout0_122) AT=695.025n

.meas tran vdout0_123ck1380 FIND v(dout0_123) AT=695.025n

.meas tran vdout0_124ck1380 FIND v(dout0_124) AT=695.025n

.meas tran vdout0_125ck1380 FIND v(dout0_125) AT=695.025n

.meas tran vdout0_126ck1380 FIND v(dout0_126) AT=695.025n

.meas tran vdout0_127ck1380 FIND v(dout0_127) AT=695.025n

.meas tran vdout0_0ck1390 FIND v(dout0_0) AT=700.025n

.meas tran vdout0_1ck1390 FIND v(dout0_1) AT=700.025n

.meas tran vdout0_2ck1390 FIND v(dout0_2) AT=700.025n

.meas tran vdout0_3ck1390 FIND v(dout0_3) AT=700.025n

.meas tran vdout0_4ck1390 FIND v(dout0_4) AT=700.025n

.meas tran vdout0_5ck1390 FIND v(dout0_5) AT=700.025n

.meas tran vdout0_6ck1390 FIND v(dout0_6) AT=700.025n

.meas tran vdout0_7ck1390 FIND v(dout0_7) AT=700.025n

.meas tran vdout0_8ck1390 FIND v(dout0_8) AT=700.025n

.meas tran vdout0_9ck1390 FIND v(dout0_9) AT=700.025n

.meas tran vdout0_10ck1390 FIND v(dout0_10) AT=700.025n

.meas tran vdout0_11ck1390 FIND v(dout0_11) AT=700.025n

.meas tran vdout0_12ck1390 FIND v(dout0_12) AT=700.025n

.meas tran vdout0_13ck1390 FIND v(dout0_13) AT=700.025n

.meas tran vdout0_14ck1390 FIND v(dout0_14) AT=700.025n

.meas tran vdout0_15ck1390 FIND v(dout0_15) AT=700.025n

.meas tran vdout0_16ck1390 FIND v(dout0_16) AT=700.025n

.meas tran vdout0_17ck1390 FIND v(dout0_17) AT=700.025n

.meas tran vdout0_18ck1390 FIND v(dout0_18) AT=700.025n

.meas tran vdout0_19ck1390 FIND v(dout0_19) AT=700.025n

.meas tran vdout0_20ck1390 FIND v(dout0_20) AT=700.025n

.meas tran vdout0_21ck1390 FIND v(dout0_21) AT=700.025n

.meas tran vdout0_22ck1390 FIND v(dout0_22) AT=700.025n

.meas tran vdout0_23ck1390 FIND v(dout0_23) AT=700.025n

.meas tran vdout0_24ck1390 FIND v(dout0_24) AT=700.025n

.meas tran vdout0_25ck1390 FIND v(dout0_25) AT=700.025n

.meas tran vdout0_26ck1390 FIND v(dout0_26) AT=700.025n

.meas tran vdout0_27ck1390 FIND v(dout0_27) AT=700.025n

.meas tran vdout0_28ck1390 FIND v(dout0_28) AT=700.025n

.meas tran vdout0_29ck1390 FIND v(dout0_29) AT=700.025n

.meas tran vdout0_30ck1390 FIND v(dout0_30) AT=700.025n

.meas tran vdout0_31ck1390 FIND v(dout0_31) AT=700.025n

.meas tran vdout0_32ck1390 FIND v(dout0_32) AT=700.025n

.meas tran vdout0_33ck1390 FIND v(dout0_33) AT=700.025n

.meas tran vdout0_34ck1390 FIND v(dout0_34) AT=700.025n

.meas tran vdout0_35ck1390 FIND v(dout0_35) AT=700.025n

.meas tran vdout0_36ck1390 FIND v(dout0_36) AT=700.025n

.meas tran vdout0_37ck1390 FIND v(dout0_37) AT=700.025n

.meas tran vdout0_38ck1390 FIND v(dout0_38) AT=700.025n

.meas tran vdout0_39ck1390 FIND v(dout0_39) AT=700.025n

.meas tran vdout0_40ck1390 FIND v(dout0_40) AT=700.025n

.meas tran vdout0_41ck1390 FIND v(dout0_41) AT=700.025n

.meas tran vdout0_42ck1390 FIND v(dout0_42) AT=700.025n

.meas tran vdout0_43ck1390 FIND v(dout0_43) AT=700.025n

.meas tran vdout0_44ck1390 FIND v(dout0_44) AT=700.025n

.meas tran vdout0_45ck1390 FIND v(dout0_45) AT=700.025n

.meas tran vdout0_46ck1390 FIND v(dout0_46) AT=700.025n

.meas tran vdout0_47ck1390 FIND v(dout0_47) AT=700.025n

.meas tran vdout0_48ck1390 FIND v(dout0_48) AT=700.025n

.meas tran vdout0_49ck1390 FIND v(dout0_49) AT=700.025n

.meas tran vdout0_50ck1390 FIND v(dout0_50) AT=700.025n

.meas tran vdout0_51ck1390 FIND v(dout0_51) AT=700.025n

.meas tran vdout0_52ck1390 FIND v(dout0_52) AT=700.025n

.meas tran vdout0_53ck1390 FIND v(dout0_53) AT=700.025n

.meas tran vdout0_54ck1390 FIND v(dout0_54) AT=700.025n

.meas tran vdout0_55ck1390 FIND v(dout0_55) AT=700.025n

.meas tran vdout0_56ck1390 FIND v(dout0_56) AT=700.025n

.meas tran vdout0_57ck1390 FIND v(dout0_57) AT=700.025n

.meas tran vdout0_58ck1390 FIND v(dout0_58) AT=700.025n

.meas tran vdout0_59ck1390 FIND v(dout0_59) AT=700.025n

.meas tran vdout0_60ck1390 FIND v(dout0_60) AT=700.025n

.meas tran vdout0_61ck1390 FIND v(dout0_61) AT=700.025n

.meas tran vdout0_62ck1390 FIND v(dout0_62) AT=700.025n

.meas tran vdout0_63ck1390 FIND v(dout0_63) AT=700.025n

.meas tran vdout0_64ck1390 FIND v(dout0_64) AT=700.025n

.meas tran vdout0_65ck1390 FIND v(dout0_65) AT=700.025n

.meas tran vdout0_66ck1390 FIND v(dout0_66) AT=700.025n

.meas tran vdout0_67ck1390 FIND v(dout0_67) AT=700.025n

.meas tran vdout0_68ck1390 FIND v(dout0_68) AT=700.025n

.meas tran vdout0_69ck1390 FIND v(dout0_69) AT=700.025n

.meas tran vdout0_70ck1390 FIND v(dout0_70) AT=700.025n

.meas tran vdout0_71ck1390 FIND v(dout0_71) AT=700.025n

.meas tran vdout0_72ck1390 FIND v(dout0_72) AT=700.025n

.meas tran vdout0_73ck1390 FIND v(dout0_73) AT=700.025n

.meas tran vdout0_74ck1390 FIND v(dout0_74) AT=700.025n

.meas tran vdout0_75ck1390 FIND v(dout0_75) AT=700.025n

.meas tran vdout0_76ck1390 FIND v(dout0_76) AT=700.025n

.meas tran vdout0_77ck1390 FIND v(dout0_77) AT=700.025n

.meas tran vdout0_78ck1390 FIND v(dout0_78) AT=700.025n

.meas tran vdout0_79ck1390 FIND v(dout0_79) AT=700.025n

.meas tran vdout0_80ck1390 FIND v(dout0_80) AT=700.025n

.meas tran vdout0_81ck1390 FIND v(dout0_81) AT=700.025n

.meas tran vdout0_82ck1390 FIND v(dout0_82) AT=700.025n

.meas tran vdout0_83ck1390 FIND v(dout0_83) AT=700.025n

.meas tran vdout0_84ck1390 FIND v(dout0_84) AT=700.025n

.meas tran vdout0_85ck1390 FIND v(dout0_85) AT=700.025n

.meas tran vdout0_86ck1390 FIND v(dout0_86) AT=700.025n

.meas tran vdout0_87ck1390 FIND v(dout0_87) AT=700.025n

.meas tran vdout0_88ck1390 FIND v(dout0_88) AT=700.025n

.meas tran vdout0_89ck1390 FIND v(dout0_89) AT=700.025n

.meas tran vdout0_90ck1390 FIND v(dout0_90) AT=700.025n

.meas tran vdout0_91ck1390 FIND v(dout0_91) AT=700.025n

.meas tran vdout0_92ck1390 FIND v(dout0_92) AT=700.025n

.meas tran vdout0_93ck1390 FIND v(dout0_93) AT=700.025n

.meas tran vdout0_94ck1390 FIND v(dout0_94) AT=700.025n

.meas tran vdout0_95ck1390 FIND v(dout0_95) AT=700.025n

.meas tran vdout0_96ck1390 FIND v(dout0_96) AT=700.025n

.meas tran vdout0_97ck1390 FIND v(dout0_97) AT=700.025n

.meas tran vdout0_98ck1390 FIND v(dout0_98) AT=700.025n

.meas tran vdout0_99ck1390 FIND v(dout0_99) AT=700.025n

.meas tran vdout0_100ck1390 FIND v(dout0_100) AT=700.025n

.meas tran vdout0_101ck1390 FIND v(dout0_101) AT=700.025n

.meas tran vdout0_102ck1390 FIND v(dout0_102) AT=700.025n

.meas tran vdout0_103ck1390 FIND v(dout0_103) AT=700.025n

.meas tran vdout0_104ck1390 FIND v(dout0_104) AT=700.025n

.meas tran vdout0_105ck1390 FIND v(dout0_105) AT=700.025n

.meas tran vdout0_106ck1390 FIND v(dout0_106) AT=700.025n

.meas tran vdout0_107ck1390 FIND v(dout0_107) AT=700.025n

.meas tran vdout0_108ck1390 FIND v(dout0_108) AT=700.025n

.meas tran vdout0_109ck1390 FIND v(dout0_109) AT=700.025n

.meas tran vdout0_110ck1390 FIND v(dout0_110) AT=700.025n

.meas tran vdout0_111ck1390 FIND v(dout0_111) AT=700.025n

.meas tran vdout0_112ck1390 FIND v(dout0_112) AT=700.025n

.meas tran vdout0_113ck1390 FIND v(dout0_113) AT=700.025n

.meas tran vdout0_114ck1390 FIND v(dout0_114) AT=700.025n

.meas tran vdout0_115ck1390 FIND v(dout0_115) AT=700.025n

.meas tran vdout0_116ck1390 FIND v(dout0_116) AT=700.025n

.meas tran vdout0_117ck1390 FIND v(dout0_117) AT=700.025n

.meas tran vdout0_118ck1390 FIND v(dout0_118) AT=700.025n

.meas tran vdout0_119ck1390 FIND v(dout0_119) AT=700.025n

.meas tran vdout0_120ck1390 FIND v(dout0_120) AT=700.025n

.meas tran vdout0_121ck1390 FIND v(dout0_121) AT=700.025n

.meas tran vdout0_122ck1390 FIND v(dout0_122) AT=700.025n

.meas tran vdout0_123ck1390 FIND v(dout0_123) AT=700.025n

.meas tran vdout0_124ck1390 FIND v(dout0_124) AT=700.025n

.meas tran vdout0_125ck1390 FIND v(dout0_125) AT=700.025n

.meas tran vdout0_126ck1390 FIND v(dout0_126) AT=700.025n

.meas tran vdout0_127ck1390 FIND v(dout0_127) AT=700.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_0ck1410 FIND v(dout0_0) AT=710.025n

.meas tran vdout0_1ck1410 FIND v(dout0_1) AT=710.025n

.meas tran vdout0_2ck1410 FIND v(dout0_2) AT=710.025n

.meas tran vdout0_3ck1410 FIND v(dout0_3) AT=710.025n

.meas tran vdout0_4ck1410 FIND v(dout0_4) AT=710.025n

.meas tran vdout0_5ck1410 FIND v(dout0_5) AT=710.025n

.meas tran vdout0_6ck1410 FIND v(dout0_6) AT=710.025n

.meas tran vdout0_7ck1410 FIND v(dout0_7) AT=710.025n

.meas tran vdout0_8ck1410 FIND v(dout0_8) AT=710.025n

.meas tran vdout0_9ck1410 FIND v(dout0_9) AT=710.025n

.meas tran vdout0_10ck1410 FIND v(dout0_10) AT=710.025n

.meas tran vdout0_11ck1410 FIND v(dout0_11) AT=710.025n

.meas tran vdout0_12ck1410 FIND v(dout0_12) AT=710.025n

.meas tran vdout0_13ck1410 FIND v(dout0_13) AT=710.025n

.meas tran vdout0_14ck1410 FIND v(dout0_14) AT=710.025n

.meas tran vdout0_15ck1410 FIND v(dout0_15) AT=710.025n

.meas tran vdout0_16ck1410 FIND v(dout0_16) AT=710.025n

.meas tran vdout0_17ck1410 FIND v(dout0_17) AT=710.025n

.meas tran vdout0_18ck1410 FIND v(dout0_18) AT=710.025n

.meas tran vdout0_19ck1410 FIND v(dout0_19) AT=710.025n

.meas tran vdout0_20ck1410 FIND v(dout0_20) AT=710.025n

.meas tran vdout0_21ck1410 FIND v(dout0_21) AT=710.025n

.meas tran vdout0_22ck1410 FIND v(dout0_22) AT=710.025n

.meas tran vdout0_23ck1410 FIND v(dout0_23) AT=710.025n

.meas tran vdout0_24ck1410 FIND v(dout0_24) AT=710.025n

.meas tran vdout0_25ck1410 FIND v(dout0_25) AT=710.025n

.meas tran vdout0_26ck1410 FIND v(dout0_26) AT=710.025n

.meas tran vdout0_27ck1410 FIND v(dout0_27) AT=710.025n

.meas tran vdout0_28ck1410 FIND v(dout0_28) AT=710.025n

.meas tran vdout0_29ck1410 FIND v(dout0_29) AT=710.025n

.meas tran vdout0_30ck1410 FIND v(dout0_30) AT=710.025n

.meas tran vdout0_31ck1410 FIND v(dout0_31) AT=710.025n

.meas tran vdout0_32ck1410 FIND v(dout0_32) AT=710.025n

.meas tran vdout0_33ck1410 FIND v(dout0_33) AT=710.025n

.meas tran vdout0_34ck1410 FIND v(dout0_34) AT=710.025n

.meas tran vdout0_35ck1410 FIND v(dout0_35) AT=710.025n

.meas tran vdout0_36ck1410 FIND v(dout0_36) AT=710.025n

.meas tran vdout0_37ck1410 FIND v(dout0_37) AT=710.025n

.meas tran vdout0_38ck1410 FIND v(dout0_38) AT=710.025n

.meas tran vdout0_39ck1410 FIND v(dout0_39) AT=710.025n

.meas tran vdout0_40ck1410 FIND v(dout0_40) AT=710.025n

.meas tran vdout0_41ck1410 FIND v(dout0_41) AT=710.025n

.meas tran vdout0_42ck1410 FIND v(dout0_42) AT=710.025n

.meas tran vdout0_43ck1410 FIND v(dout0_43) AT=710.025n

.meas tran vdout0_44ck1410 FIND v(dout0_44) AT=710.025n

.meas tran vdout0_45ck1410 FIND v(dout0_45) AT=710.025n

.meas tran vdout0_46ck1410 FIND v(dout0_46) AT=710.025n

.meas tran vdout0_47ck1410 FIND v(dout0_47) AT=710.025n

.meas tran vdout0_48ck1410 FIND v(dout0_48) AT=710.025n

.meas tran vdout0_49ck1410 FIND v(dout0_49) AT=710.025n

.meas tran vdout0_50ck1410 FIND v(dout0_50) AT=710.025n

.meas tran vdout0_51ck1410 FIND v(dout0_51) AT=710.025n

.meas tran vdout0_52ck1410 FIND v(dout0_52) AT=710.025n

.meas tran vdout0_53ck1410 FIND v(dout0_53) AT=710.025n

.meas tran vdout0_54ck1410 FIND v(dout0_54) AT=710.025n

.meas tran vdout0_55ck1410 FIND v(dout0_55) AT=710.025n

.meas tran vdout0_56ck1410 FIND v(dout0_56) AT=710.025n

.meas tran vdout0_57ck1410 FIND v(dout0_57) AT=710.025n

.meas tran vdout0_58ck1410 FIND v(dout0_58) AT=710.025n

.meas tran vdout0_59ck1410 FIND v(dout0_59) AT=710.025n

.meas tran vdout0_60ck1410 FIND v(dout0_60) AT=710.025n

.meas tran vdout0_61ck1410 FIND v(dout0_61) AT=710.025n

.meas tran vdout0_62ck1410 FIND v(dout0_62) AT=710.025n

.meas tran vdout0_63ck1410 FIND v(dout0_63) AT=710.025n

.meas tran vdout0_64ck1410 FIND v(dout0_64) AT=710.025n

.meas tran vdout0_65ck1410 FIND v(dout0_65) AT=710.025n

.meas tran vdout0_66ck1410 FIND v(dout0_66) AT=710.025n

.meas tran vdout0_67ck1410 FIND v(dout0_67) AT=710.025n

.meas tran vdout0_68ck1410 FIND v(dout0_68) AT=710.025n

.meas tran vdout0_69ck1410 FIND v(dout0_69) AT=710.025n

.meas tran vdout0_70ck1410 FIND v(dout0_70) AT=710.025n

.meas tran vdout0_71ck1410 FIND v(dout0_71) AT=710.025n

.meas tran vdout0_72ck1410 FIND v(dout0_72) AT=710.025n

.meas tran vdout0_73ck1410 FIND v(dout0_73) AT=710.025n

.meas tran vdout0_74ck1410 FIND v(dout0_74) AT=710.025n

.meas tran vdout0_75ck1410 FIND v(dout0_75) AT=710.025n

.meas tran vdout0_76ck1410 FIND v(dout0_76) AT=710.025n

.meas tran vdout0_77ck1410 FIND v(dout0_77) AT=710.025n

.meas tran vdout0_78ck1410 FIND v(dout0_78) AT=710.025n

.meas tran vdout0_79ck1410 FIND v(dout0_79) AT=710.025n

.meas tran vdout0_80ck1410 FIND v(dout0_80) AT=710.025n

.meas tran vdout0_81ck1410 FIND v(dout0_81) AT=710.025n

.meas tran vdout0_82ck1410 FIND v(dout0_82) AT=710.025n

.meas tran vdout0_83ck1410 FIND v(dout0_83) AT=710.025n

.meas tran vdout0_84ck1410 FIND v(dout0_84) AT=710.025n

.meas tran vdout0_85ck1410 FIND v(dout0_85) AT=710.025n

.meas tran vdout0_86ck1410 FIND v(dout0_86) AT=710.025n

.meas tran vdout0_87ck1410 FIND v(dout0_87) AT=710.025n

.meas tran vdout0_88ck1410 FIND v(dout0_88) AT=710.025n

.meas tran vdout0_89ck1410 FIND v(dout0_89) AT=710.025n

.meas tran vdout0_90ck1410 FIND v(dout0_90) AT=710.025n

.meas tran vdout0_91ck1410 FIND v(dout0_91) AT=710.025n

.meas tran vdout0_92ck1410 FIND v(dout0_92) AT=710.025n

.meas tran vdout0_93ck1410 FIND v(dout0_93) AT=710.025n

.meas tran vdout0_94ck1410 FIND v(dout0_94) AT=710.025n

.meas tran vdout0_95ck1410 FIND v(dout0_95) AT=710.025n

.meas tran vdout0_96ck1410 FIND v(dout0_96) AT=710.025n

.meas tran vdout0_97ck1410 FIND v(dout0_97) AT=710.025n

.meas tran vdout0_98ck1410 FIND v(dout0_98) AT=710.025n

.meas tran vdout0_99ck1410 FIND v(dout0_99) AT=710.025n

.meas tran vdout0_100ck1410 FIND v(dout0_100) AT=710.025n

.meas tran vdout0_101ck1410 FIND v(dout0_101) AT=710.025n

.meas tran vdout0_102ck1410 FIND v(dout0_102) AT=710.025n

.meas tran vdout0_103ck1410 FIND v(dout0_103) AT=710.025n

.meas tran vdout0_104ck1410 FIND v(dout0_104) AT=710.025n

.meas tran vdout0_105ck1410 FIND v(dout0_105) AT=710.025n

.meas tran vdout0_106ck1410 FIND v(dout0_106) AT=710.025n

.meas tran vdout0_107ck1410 FIND v(dout0_107) AT=710.025n

.meas tran vdout0_108ck1410 FIND v(dout0_108) AT=710.025n

.meas tran vdout0_109ck1410 FIND v(dout0_109) AT=710.025n

.meas tran vdout0_110ck1410 FIND v(dout0_110) AT=710.025n

.meas tran vdout0_111ck1410 FIND v(dout0_111) AT=710.025n

.meas tran vdout0_112ck1410 FIND v(dout0_112) AT=710.025n

.meas tran vdout0_113ck1410 FIND v(dout0_113) AT=710.025n

.meas tran vdout0_114ck1410 FIND v(dout0_114) AT=710.025n

.meas tran vdout0_115ck1410 FIND v(dout0_115) AT=710.025n

.meas tran vdout0_116ck1410 FIND v(dout0_116) AT=710.025n

.meas tran vdout0_117ck1410 FIND v(dout0_117) AT=710.025n

.meas tran vdout0_118ck1410 FIND v(dout0_118) AT=710.025n

.meas tran vdout0_119ck1410 FIND v(dout0_119) AT=710.025n

.meas tran vdout0_120ck1410 FIND v(dout0_120) AT=710.025n

.meas tran vdout0_121ck1410 FIND v(dout0_121) AT=710.025n

.meas tran vdout0_122ck1410 FIND v(dout0_122) AT=710.025n

.meas tran vdout0_123ck1410 FIND v(dout0_123) AT=710.025n

.meas tran vdout0_124ck1410 FIND v(dout0_124) AT=710.025n

.meas tran vdout0_125ck1410 FIND v(dout0_125) AT=710.025n

.meas tran vdout0_126ck1410 FIND v(dout0_126) AT=710.025n

.meas tran vdout0_127ck1410 FIND v(dout0_127) AT=710.025n

.meas tran vdout0_0ck1420 FIND v(dout0_0) AT=715.025n

.meas tran vdout0_1ck1420 FIND v(dout0_1) AT=715.025n

.meas tran vdout0_2ck1420 FIND v(dout0_2) AT=715.025n

.meas tran vdout0_3ck1420 FIND v(dout0_3) AT=715.025n

.meas tran vdout0_4ck1420 FIND v(dout0_4) AT=715.025n

.meas tran vdout0_5ck1420 FIND v(dout0_5) AT=715.025n

.meas tran vdout0_6ck1420 FIND v(dout0_6) AT=715.025n

.meas tran vdout0_7ck1420 FIND v(dout0_7) AT=715.025n

.meas tran vdout0_8ck1420 FIND v(dout0_8) AT=715.025n

.meas tran vdout0_9ck1420 FIND v(dout0_9) AT=715.025n

.meas tran vdout0_10ck1420 FIND v(dout0_10) AT=715.025n

.meas tran vdout0_11ck1420 FIND v(dout0_11) AT=715.025n

.meas tran vdout0_12ck1420 FIND v(dout0_12) AT=715.025n

.meas tran vdout0_13ck1420 FIND v(dout0_13) AT=715.025n

.meas tran vdout0_14ck1420 FIND v(dout0_14) AT=715.025n

.meas tran vdout0_15ck1420 FIND v(dout0_15) AT=715.025n

.meas tran vdout0_16ck1420 FIND v(dout0_16) AT=715.025n

.meas tran vdout0_17ck1420 FIND v(dout0_17) AT=715.025n

.meas tran vdout0_18ck1420 FIND v(dout0_18) AT=715.025n

.meas tran vdout0_19ck1420 FIND v(dout0_19) AT=715.025n

.meas tran vdout0_20ck1420 FIND v(dout0_20) AT=715.025n

.meas tran vdout0_21ck1420 FIND v(dout0_21) AT=715.025n

.meas tran vdout0_22ck1420 FIND v(dout0_22) AT=715.025n

.meas tran vdout0_23ck1420 FIND v(dout0_23) AT=715.025n

.meas tran vdout0_24ck1420 FIND v(dout0_24) AT=715.025n

.meas tran vdout0_25ck1420 FIND v(dout0_25) AT=715.025n

.meas tran vdout0_26ck1420 FIND v(dout0_26) AT=715.025n

.meas tran vdout0_27ck1420 FIND v(dout0_27) AT=715.025n

.meas tran vdout0_28ck1420 FIND v(dout0_28) AT=715.025n

.meas tran vdout0_29ck1420 FIND v(dout0_29) AT=715.025n

.meas tran vdout0_30ck1420 FIND v(dout0_30) AT=715.025n

.meas tran vdout0_31ck1420 FIND v(dout0_31) AT=715.025n

.meas tran vdout0_32ck1420 FIND v(dout0_32) AT=715.025n

.meas tran vdout0_33ck1420 FIND v(dout0_33) AT=715.025n

.meas tran vdout0_34ck1420 FIND v(dout0_34) AT=715.025n

.meas tran vdout0_35ck1420 FIND v(dout0_35) AT=715.025n

.meas tran vdout0_36ck1420 FIND v(dout0_36) AT=715.025n

.meas tran vdout0_37ck1420 FIND v(dout0_37) AT=715.025n

.meas tran vdout0_38ck1420 FIND v(dout0_38) AT=715.025n

.meas tran vdout0_39ck1420 FIND v(dout0_39) AT=715.025n

.meas tran vdout0_40ck1420 FIND v(dout0_40) AT=715.025n

.meas tran vdout0_41ck1420 FIND v(dout0_41) AT=715.025n

.meas tran vdout0_42ck1420 FIND v(dout0_42) AT=715.025n

.meas tran vdout0_43ck1420 FIND v(dout0_43) AT=715.025n

.meas tran vdout0_44ck1420 FIND v(dout0_44) AT=715.025n

.meas tran vdout0_45ck1420 FIND v(dout0_45) AT=715.025n

.meas tran vdout0_46ck1420 FIND v(dout0_46) AT=715.025n

.meas tran vdout0_47ck1420 FIND v(dout0_47) AT=715.025n

.meas tran vdout0_48ck1420 FIND v(dout0_48) AT=715.025n

.meas tran vdout0_49ck1420 FIND v(dout0_49) AT=715.025n

.meas tran vdout0_50ck1420 FIND v(dout0_50) AT=715.025n

.meas tran vdout0_51ck1420 FIND v(dout0_51) AT=715.025n

.meas tran vdout0_52ck1420 FIND v(dout0_52) AT=715.025n

.meas tran vdout0_53ck1420 FIND v(dout0_53) AT=715.025n

.meas tran vdout0_54ck1420 FIND v(dout0_54) AT=715.025n

.meas tran vdout0_55ck1420 FIND v(dout0_55) AT=715.025n

.meas tran vdout0_56ck1420 FIND v(dout0_56) AT=715.025n

.meas tran vdout0_57ck1420 FIND v(dout0_57) AT=715.025n

.meas tran vdout0_58ck1420 FIND v(dout0_58) AT=715.025n

.meas tran vdout0_59ck1420 FIND v(dout0_59) AT=715.025n

.meas tran vdout0_60ck1420 FIND v(dout0_60) AT=715.025n

.meas tran vdout0_61ck1420 FIND v(dout0_61) AT=715.025n

.meas tran vdout0_62ck1420 FIND v(dout0_62) AT=715.025n

.meas tran vdout0_63ck1420 FIND v(dout0_63) AT=715.025n

.meas tran vdout0_64ck1420 FIND v(dout0_64) AT=715.025n

.meas tran vdout0_65ck1420 FIND v(dout0_65) AT=715.025n

.meas tran vdout0_66ck1420 FIND v(dout0_66) AT=715.025n

.meas tran vdout0_67ck1420 FIND v(dout0_67) AT=715.025n

.meas tran vdout0_68ck1420 FIND v(dout0_68) AT=715.025n

.meas tran vdout0_69ck1420 FIND v(dout0_69) AT=715.025n

.meas tran vdout0_70ck1420 FIND v(dout0_70) AT=715.025n

.meas tran vdout0_71ck1420 FIND v(dout0_71) AT=715.025n

.meas tran vdout0_72ck1420 FIND v(dout0_72) AT=715.025n

.meas tran vdout0_73ck1420 FIND v(dout0_73) AT=715.025n

.meas tran vdout0_74ck1420 FIND v(dout0_74) AT=715.025n

.meas tran vdout0_75ck1420 FIND v(dout0_75) AT=715.025n

.meas tran vdout0_76ck1420 FIND v(dout0_76) AT=715.025n

.meas tran vdout0_77ck1420 FIND v(dout0_77) AT=715.025n

.meas tran vdout0_78ck1420 FIND v(dout0_78) AT=715.025n

.meas tran vdout0_79ck1420 FIND v(dout0_79) AT=715.025n

.meas tran vdout0_80ck1420 FIND v(dout0_80) AT=715.025n

.meas tran vdout0_81ck1420 FIND v(dout0_81) AT=715.025n

.meas tran vdout0_82ck1420 FIND v(dout0_82) AT=715.025n

.meas tran vdout0_83ck1420 FIND v(dout0_83) AT=715.025n

.meas tran vdout0_84ck1420 FIND v(dout0_84) AT=715.025n

.meas tran vdout0_85ck1420 FIND v(dout0_85) AT=715.025n

.meas tran vdout0_86ck1420 FIND v(dout0_86) AT=715.025n

.meas tran vdout0_87ck1420 FIND v(dout0_87) AT=715.025n

.meas tran vdout0_88ck1420 FIND v(dout0_88) AT=715.025n

.meas tran vdout0_89ck1420 FIND v(dout0_89) AT=715.025n

.meas tran vdout0_90ck1420 FIND v(dout0_90) AT=715.025n

.meas tran vdout0_91ck1420 FIND v(dout0_91) AT=715.025n

.meas tran vdout0_92ck1420 FIND v(dout0_92) AT=715.025n

.meas tran vdout0_93ck1420 FIND v(dout0_93) AT=715.025n

.meas tran vdout0_94ck1420 FIND v(dout0_94) AT=715.025n

.meas tran vdout0_95ck1420 FIND v(dout0_95) AT=715.025n

.meas tran vdout0_96ck1420 FIND v(dout0_96) AT=715.025n

.meas tran vdout0_97ck1420 FIND v(dout0_97) AT=715.025n

.meas tran vdout0_98ck1420 FIND v(dout0_98) AT=715.025n

.meas tran vdout0_99ck1420 FIND v(dout0_99) AT=715.025n

.meas tran vdout0_100ck1420 FIND v(dout0_100) AT=715.025n

.meas tran vdout0_101ck1420 FIND v(dout0_101) AT=715.025n

.meas tran vdout0_102ck1420 FIND v(dout0_102) AT=715.025n

.meas tran vdout0_103ck1420 FIND v(dout0_103) AT=715.025n

.meas tran vdout0_104ck1420 FIND v(dout0_104) AT=715.025n

.meas tran vdout0_105ck1420 FIND v(dout0_105) AT=715.025n

.meas tran vdout0_106ck1420 FIND v(dout0_106) AT=715.025n

.meas tran vdout0_107ck1420 FIND v(dout0_107) AT=715.025n

.meas tran vdout0_108ck1420 FIND v(dout0_108) AT=715.025n

.meas tran vdout0_109ck1420 FIND v(dout0_109) AT=715.025n

.meas tran vdout0_110ck1420 FIND v(dout0_110) AT=715.025n

.meas tran vdout0_111ck1420 FIND v(dout0_111) AT=715.025n

.meas tran vdout0_112ck1420 FIND v(dout0_112) AT=715.025n

.meas tran vdout0_113ck1420 FIND v(dout0_113) AT=715.025n

.meas tran vdout0_114ck1420 FIND v(dout0_114) AT=715.025n

.meas tran vdout0_115ck1420 FIND v(dout0_115) AT=715.025n

.meas tran vdout0_116ck1420 FIND v(dout0_116) AT=715.025n

.meas tran vdout0_117ck1420 FIND v(dout0_117) AT=715.025n

.meas tran vdout0_118ck1420 FIND v(dout0_118) AT=715.025n

.meas tran vdout0_119ck1420 FIND v(dout0_119) AT=715.025n

.meas tran vdout0_120ck1420 FIND v(dout0_120) AT=715.025n

.meas tran vdout0_121ck1420 FIND v(dout0_121) AT=715.025n

.meas tran vdout0_122ck1420 FIND v(dout0_122) AT=715.025n

.meas tran vdout0_123ck1420 FIND v(dout0_123) AT=715.025n

.meas tran vdout0_124ck1420 FIND v(dout0_124) AT=715.025n

.meas tran vdout0_125ck1420 FIND v(dout0_125) AT=715.025n

.meas tran vdout0_126ck1420 FIND v(dout0_126) AT=715.025n

.meas tran vdout0_127ck1420 FIND v(dout0_127) AT=715.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_0ck1470 FIND v(dout0_0) AT=740.025n

.meas tran vdout0_1ck1470 FIND v(dout0_1) AT=740.025n

.meas tran vdout0_2ck1470 FIND v(dout0_2) AT=740.025n

.meas tran vdout0_3ck1470 FIND v(dout0_3) AT=740.025n

.meas tran vdout0_4ck1470 FIND v(dout0_4) AT=740.025n

.meas tran vdout0_5ck1470 FIND v(dout0_5) AT=740.025n

.meas tran vdout0_6ck1470 FIND v(dout0_6) AT=740.025n

.meas tran vdout0_7ck1470 FIND v(dout0_7) AT=740.025n

.meas tran vdout0_8ck1470 FIND v(dout0_8) AT=740.025n

.meas tran vdout0_9ck1470 FIND v(dout0_9) AT=740.025n

.meas tran vdout0_10ck1470 FIND v(dout0_10) AT=740.025n

.meas tran vdout0_11ck1470 FIND v(dout0_11) AT=740.025n

.meas tran vdout0_12ck1470 FIND v(dout0_12) AT=740.025n

.meas tran vdout0_13ck1470 FIND v(dout0_13) AT=740.025n

.meas tran vdout0_14ck1470 FIND v(dout0_14) AT=740.025n

.meas tran vdout0_15ck1470 FIND v(dout0_15) AT=740.025n

.meas tran vdout0_16ck1470 FIND v(dout0_16) AT=740.025n

.meas tran vdout0_17ck1470 FIND v(dout0_17) AT=740.025n

.meas tran vdout0_18ck1470 FIND v(dout0_18) AT=740.025n

.meas tran vdout0_19ck1470 FIND v(dout0_19) AT=740.025n

.meas tran vdout0_20ck1470 FIND v(dout0_20) AT=740.025n

.meas tran vdout0_21ck1470 FIND v(dout0_21) AT=740.025n

.meas tran vdout0_22ck1470 FIND v(dout0_22) AT=740.025n

.meas tran vdout0_23ck1470 FIND v(dout0_23) AT=740.025n

.meas tran vdout0_24ck1470 FIND v(dout0_24) AT=740.025n

.meas tran vdout0_25ck1470 FIND v(dout0_25) AT=740.025n

.meas tran vdout0_26ck1470 FIND v(dout0_26) AT=740.025n

.meas tran vdout0_27ck1470 FIND v(dout0_27) AT=740.025n

.meas tran vdout0_28ck1470 FIND v(dout0_28) AT=740.025n

.meas tran vdout0_29ck1470 FIND v(dout0_29) AT=740.025n

.meas tran vdout0_30ck1470 FIND v(dout0_30) AT=740.025n

.meas tran vdout0_31ck1470 FIND v(dout0_31) AT=740.025n

.meas tran vdout0_32ck1470 FIND v(dout0_32) AT=740.025n

.meas tran vdout0_33ck1470 FIND v(dout0_33) AT=740.025n

.meas tran vdout0_34ck1470 FIND v(dout0_34) AT=740.025n

.meas tran vdout0_35ck1470 FIND v(dout0_35) AT=740.025n

.meas tran vdout0_36ck1470 FIND v(dout0_36) AT=740.025n

.meas tran vdout0_37ck1470 FIND v(dout0_37) AT=740.025n

.meas tran vdout0_38ck1470 FIND v(dout0_38) AT=740.025n

.meas tran vdout0_39ck1470 FIND v(dout0_39) AT=740.025n

.meas tran vdout0_40ck1470 FIND v(dout0_40) AT=740.025n

.meas tran vdout0_41ck1470 FIND v(dout0_41) AT=740.025n

.meas tran vdout0_42ck1470 FIND v(dout0_42) AT=740.025n

.meas tran vdout0_43ck1470 FIND v(dout0_43) AT=740.025n

.meas tran vdout0_44ck1470 FIND v(dout0_44) AT=740.025n

.meas tran vdout0_45ck1470 FIND v(dout0_45) AT=740.025n

.meas tran vdout0_46ck1470 FIND v(dout0_46) AT=740.025n

.meas tran vdout0_47ck1470 FIND v(dout0_47) AT=740.025n

.meas tran vdout0_48ck1470 FIND v(dout0_48) AT=740.025n

.meas tran vdout0_49ck1470 FIND v(dout0_49) AT=740.025n

.meas tran vdout0_50ck1470 FIND v(dout0_50) AT=740.025n

.meas tran vdout0_51ck1470 FIND v(dout0_51) AT=740.025n

.meas tran vdout0_52ck1470 FIND v(dout0_52) AT=740.025n

.meas tran vdout0_53ck1470 FIND v(dout0_53) AT=740.025n

.meas tran vdout0_54ck1470 FIND v(dout0_54) AT=740.025n

.meas tran vdout0_55ck1470 FIND v(dout0_55) AT=740.025n

.meas tran vdout0_56ck1470 FIND v(dout0_56) AT=740.025n

.meas tran vdout0_57ck1470 FIND v(dout0_57) AT=740.025n

.meas tran vdout0_58ck1470 FIND v(dout0_58) AT=740.025n

.meas tran vdout0_59ck1470 FIND v(dout0_59) AT=740.025n

.meas tran vdout0_60ck1470 FIND v(dout0_60) AT=740.025n

.meas tran vdout0_61ck1470 FIND v(dout0_61) AT=740.025n

.meas tran vdout0_62ck1470 FIND v(dout0_62) AT=740.025n

.meas tran vdout0_63ck1470 FIND v(dout0_63) AT=740.025n

.meas tran vdout0_64ck1470 FIND v(dout0_64) AT=740.025n

.meas tran vdout0_65ck1470 FIND v(dout0_65) AT=740.025n

.meas tran vdout0_66ck1470 FIND v(dout0_66) AT=740.025n

.meas tran vdout0_67ck1470 FIND v(dout0_67) AT=740.025n

.meas tran vdout0_68ck1470 FIND v(dout0_68) AT=740.025n

.meas tran vdout0_69ck1470 FIND v(dout0_69) AT=740.025n

.meas tran vdout0_70ck1470 FIND v(dout0_70) AT=740.025n

.meas tran vdout0_71ck1470 FIND v(dout0_71) AT=740.025n

.meas tran vdout0_72ck1470 FIND v(dout0_72) AT=740.025n

.meas tran vdout0_73ck1470 FIND v(dout0_73) AT=740.025n

.meas tran vdout0_74ck1470 FIND v(dout0_74) AT=740.025n

.meas tran vdout0_75ck1470 FIND v(dout0_75) AT=740.025n

.meas tran vdout0_76ck1470 FIND v(dout0_76) AT=740.025n

.meas tran vdout0_77ck1470 FIND v(dout0_77) AT=740.025n

.meas tran vdout0_78ck1470 FIND v(dout0_78) AT=740.025n

.meas tran vdout0_79ck1470 FIND v(dout0_79) AT=740.025n

.meas tran vdout0_80ck1470 FIND v(dout0_80) AT=740.025n

.meas tran vdout0_81ck1470 FIND v(dout0_81) AT=740.025n

.meas tran vdout0_82ck1470 FIND v(dout0_82) AT=740.025n

.meas tran vdout0_83ck1470 FIND v(dout0_83) AT=740.025n

.meas tran vdout0_84ck1470 FIND v(dout0_84) AT=740.025n

.meas tran vdout0_85ck1470 FIND v(dout0_85) AT=740.025n

.meas tran vdout0_86ck1470 FIND v(dout0_86) AT=740.025n

.meas tran vdout0_87ck1470 FIND v(dout0_87) AT=740.025n

.meas tran vdout0_88ck1470 FIND v(dout0_88) AT=740.025n

.meas tran vdout0_89ck1470 FIND v(dout0_89) AT=740.025n

.meas tran vdout0_90ck1470 FIND v(dout0_90) AT=740.025n

.meas tran vdout0_91ck1470 FIND v(dout0_91) AT=740.025n

.meas tran vdout0_92ck1470 FIND v(dout0_92) AT=740.025n

.meas tran vdout0_93ck1470 FIND v(dout0_93) AT=740.025n

.meas tran vdout0_94ck1470 FIND v(dout0_94) AT=740.025n

.meas tran vdout0_95ck1470 FIND v(dout0_95) AT=740.025n

.meas tran vdout0_96ck1470 FIND v(dout0_96) AT=740.025n

.meas tran vdout0_97ck1470 FIND v(dout0_97) AT=740.025n

.meas tran vdout0_98ck1470 FIND v(dout0_98) AT=740.025n

.meas tran vdout0_99ck1470 FIND v(dout0_99) AT=740.025n

.meas tran vdout0_100ck1470 FIND v(dout0_100) AT=740.025n

.meas tran vdout0_101ck1470 FIND v(dout0_101) AT=740.025n

.meas tran vdout0_102ck1470 FIND v(dout0_102) AT=740.025n

.meas tran vdout0_103ck1470 FIND v(dout0_103) AT=740.025n

.meas tran vdout0_104ck1470 FIND v(dout0_104) AT=740.025n

.meas tran vdout0_105ck1470 FIND v(dout0_105) AT=740.025n

.meas tran vdout0_106ck1470 FIND v(dout0_106) AT=740.025n

.meas tran vdout0_107ck1470 FIND v(dout0_107) AT=740.025n

.meas tran vdout0_108ck1470 FIND v(dout0_108) AT=740.025n

.meas tran vdout0_109ck1470 FIND v(dout0_109) AT=740.025n

.meas tran vdout0_110ck1470 FIND v(dout0_110) AT=740.025n

.meas tran vdout0_111ck1470 FIND v(dout0_111) AT=740.025n

.meas tran vdout0_112ck1470 FIND v(dout0_112) AT=740.025n

.meas tran vdout0_113ck1470 FIND v(dout0_113) AT=740.025n

.meas tran vdout0_114ck1470 FIND v(dout0_114) AT=740.025n

.meas tran vdout0_115ck1470 FIND v(dout0_115) AT=740.025n

.meas tran vdout0_116ck1470 FIND v(dout0_116) AT=740.025n

.meas tran vdout0_117ck1470 FIND v(dout0_117) AT=740.025n

.meas tran vdout0_118ck1470 FIND v(dout0_118) AT=740.025n

.meas tran vdout0_119ck1470 FIND v(dout0_119) AT=740.025n

.meas tran vdout0_120ck1470 FIND v(dout0_120) AT=740.025n

.meas tran vdout0_121ck1470 FIND v(dout0_121) AT=740.025n

.meas tran vdout0_122ck1470 FIND v(dout0_122) AT=740.025n

.meas tran vdout0_123ck1470 FIND v(dout0_123) AT=740.025n

.meas tran vdout0_124ck1470 FIND v(dout0_124) AT=740.025n

.meas tran vdout0_125ck1470 FIND v(dout0_125) AT=740.025n

.meas tran vdout0_126ck1470 FIND v(dout0_126) AT=740.025n

.meas tran vdout0_127ck1470 FIND v(dout0_127) AT=740.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_0ck1560 FIND v(dout0_0) AT=785.025n

.meas tran vdout0_1ck1560 FIND v(dout0_1) AT=785.025n

.meas tran vdout0_2ck1560 FIND v(dout0_2) AT=785.025n

.meas tran vdout0_3ck1560 FIND v(dout0_3) AT=785.025n

.meas tran vdout0_4ck1560 FIND v(dout0_4) AT=785.025n

.meas tran vdout0_5ck1560 FIND v(dout0_5) AT=785.025n

.meas tran vdout0_6ck1560 FIND v(dout0_6) AT=785.025n

.meas tran vdout0_7ck1560 FIND v(dout0_7) AT=785.025n

.meas tran vdout0_8ck1560 FIND v(dout0_8) AT=785.025n

.meas tran vdout0_9ck1560 FIND v(dout0_9) AT=785.025n

.meas tran vdout0_10ck1560 FIND v(dout0_10) AT=785.025n

.meas tran vdout0_11ck1560 FIND v(dout0_11) AT=785.025n

.meas tran vdout0_12ck1560 FIND v(dout0_12) AT=785.025n

.meas tran vdout0_13ck1560 FIND v(dout0_13) AT=785.025n

.meas tran vdout0_14ck1560 FIND v(dout0_14) AT=785.025n

.meas tran vdout0_15ck1560 FIND v(dout0_15) AT=785.025n

.meas tran vdout0_16ck1560 FIND v(dout0_16) AT=785.025n

.meas tran vdout0_17ck1560 FIND v(dout0_17) AT=785.025n

.meas tran vdout0_18ck1560 FIND v(dout0_18) AT=785.025n

.meas tran vdout0_19ck1560 FIND v(dout0_19) AT=785.025n

.meas tran vdout0_20ck1560 FIND v(dout0_20) AT=785.025n

.meas tran vdout0_21ck1560 FIND v(dout0_21) AT=785.025n

.meas tran vdout0_22ck1560 FIND v(dout0_22) AT=785.025n

.meas tran vdout0_23ck1560 FIND v(dout0_23) AT=785.025n

.meas tran vdout0_24ck1560 FIND v(dout0_24) AT=785.025n

.meas tran vdout0_25ck1560 FIND v(dout0_25) AT=785.025n

.meas tran vdout0_26ck1560 FIND v(dout0_26) AT=785.025n

.meas tran vdout0_27ck1560 FIND v(dout0_27) AT=785.025n

.meas tran vdout0_28ck1560 FIND v(dout0_28) AT=785.025n

.meas tran vdout0_29ck1560 FIND v(dout0_29) AT=785.025n

.meas tran vdout0_30ck1560 FIND v(dout0_30) AT=785.025n

.meas tran vdout0_31ck1560 FIND v(dout0_31) AT=785.025n

.meas tran vdout0_32ck1560 FIND v(dout0_32) AT=785.025n

.meas tran vdout0_33ck1560 FIND v(dout0_33) AT=785.025n

.meas tran vdout0_34ck1560 FIND v(dout0_34) AT=785.025n

.meas tran vdout0_35ck1560 FIND v(dout0_35) AT=785.025n

.meas tran vdout0_36ck1560 FIND v(dout0_36) AT=785.025n

.meas tran vdout0_37ck1560 FIND v(dout0_37) AT=785.025n

.meas tran vdout0_38ck1560 FIND v(dout0_38) AT=785.025n

.meas tran vdout0_39ck1560 FIND v(dout0_39) AT=785.025n

.meas tran vdout0_40ck1560 FIND v(dout0_40) AT=785.025n

.meas tran vdout0_41ck1560 FIND v(dout0_41) AT=785.025n

.meas tran vdout0_42ck1560 FIND v(dout0_42) AT=785.025n

.meas tran vdout0_43ck1560 FIND v(dout0_43) AT=785.025n

.meas tran vdout0_44ck1560 FIND v(dout0_44) AT=785.025n

.meas tran vdout0_45ck1560 FIND v(dout0_45) AT=785.025n

.meas tran vdout0_46ck1560 FIND v(dout0_46) AT=785.025n

.meas tran vdout0_47ck1560 FIND v(dout0_47) AT=785.025n

.meas tran vdout0_48ck1560 FIND v(dout0_48) AT=785.025n

.meas tran vdout0_49ck1560 FIND v(dout0_49) AT=785.025n

.meas tran vdout0_50ck1560 FIND v(dout0_50) AT=785.025n

.meas tran vdout0_51ck1560 FIND v(dout0_51) AT=785.025n

.meas tran vdout0_52ck1560 FIND v(dout0_52) AT=785.025n

.meas tran vdout0_53ck1560 FIND v(dout0_53) AT=785.025n

.meas tran vdout0_54ck1560 FIND v(dout0_54) AT=785.025n

.meas tran vdout0_55ck1560 FIND v(dout0_55) AT=785.025n

.meas tran vdout0_56ck1560 FIND v(dout0_56) AT=785.025n

.meas tran vdout0_57ck1560 FIND v(dout0_57) AT=785.025n

.meas tran vdout0_58ck1560 FIND v(dout0_58) AT=785.025n

.meas tran vdout0_59ck1560 FIND v(dout0_59) AT=785.025n

.meas tran vdout0_60ck1560 FIND v(dout0_60) AT=785.025n

.meas tran vdout0_61ck1560 FIND v(dout0_61) AT=785.025n

.meas tran vdout0_62ck1560 FIND v(dout0_62) AT=785.025n

.meas tran vdout0_63ck1560 FIND v(dout0_63) AT=785.025n

.meas tran vdout0_64ck1560 FIND v(dout0_64) AT=785.025n

.meas tran vdout0_65ck1560 FIND v(dout0_65) AT=785.025n

.meas tran vdout0_66ck1560 FIND v(dout0_66) AT=785.025n

.meas tran vdout0_67ck1560 FIND v(dout0_67) AT=785.025n

.meas tran vdout0_68ck1560 FIND v(dout0_68) AT=785.025n

.meas tran vdout0_69ck1560 FIND v(dout0_69) AT=785.025n

.meas tran vdout0_70ck1560 FIND v(dout0_70) AT=785.025n

.meas tran vdout0_71ck1560 FIND v(dout0_71) AT=785.025n

.meas tran vdout0_72ck1560 FIND v(dout0_72) AT=785.025n

.meas tran vdout0_73ck1560 FIND v(dout0_73) AT=785.025n

.meas tran vdout0_74ck1560 FIND v(dout0_74) AT=785.025n

.meas tran vdout0_75ck1560 FIND v(dout0_75) AT=785.025n

.meas tran vdout0_76ck1560 FIND v(dout0_76) AT=785.025n

.meas tran vdout0_77ck1560 FIND v(dout0_77) AT=785.025n

.meas tran vdout0_78ck1560 FIND v(dout0_78) AT=785.025n

.meas tran vdout0_79ck1560 FIND v(dout0_79) AT=785.025n

.meas tran vdout0_80ck1560 FIND v(dout0_80) AT=785.025n

.meas tran vdout0_81ck1560 FIND v(dout0_81) AT=785.025n

.meas tran vdout0_82ck1560 FIND v(dout0_82) AT=785.025n

.meas tran vdout0_83ck1560 FIND v(dout0_83) AT=785.025n

.meas tran vdout0_84ck1560 FIND v(dout0_84) AT=785.025n

.meas tran vdout0_85ck1560 FIND v(dout0_85) AT=785.025n

.meas tran vdout0_86ck1560 FIND v(dout0_86) AT=785.025n

.meas tran vdout0_87ck1560 FIND v(dout0_87) AT=785.025n

.meas tran vdout0_88ck1560 FIND v(dout0_88) AT=785.025n

.meas tran vdout0_89ck1560 FIND v(dout0_89) AT=785.025n

.meas tran vdout0_90ck1560 FIND v(dout0_90) AT=785.025n

.meas tran vdout0_91ck1560 FIND v(dout0_91) AT=785.025n

.meas tran vdout0_92ck1560 FIND v(dout0_92) AT=785.025n

.meas tran vdout0_93ck1560 FIND v(dout0_93) AT=785.025n

.meas tran vdout0_94ck1560 FIND v(dout0_94) AT=785.025n

.meas tran vdout0_95ck1560 FIND v(dout0_95) AT=785.025n

.meas tran vdout0_96ck1560 FIND v(dout0_96) AT=785.025n

.meas tran vdout0_97ck1560 FIND v(dout0_97) AT=785.025n

.meas tran vdout0_98ck1560 FIND v(dout0_98) AT=785.025n

.meas tran vdout0_99ck1560 FIND v(dout0_99) AT=785.025n

.meas tran vdout0_100ck1560 FIND v(dout0_100) AT=785.025n

.meas tran vdout0_101ck1560 FIND v(dout0_101) AT=785.025n

.meas tran vdout0_102ck1560 FIND v(dout0_102) AT=785.025n

.meas tran vdout0_103ck1560 FIND v(dout0_103) AT=785.025n

.meas tran vdout0_104ck1560 FIND v(dout0_104) AT=785.025n

.meas tran vdout0_105ck1560 FIND v(dout0_105) AT=785.025n

.meas tran vdout0_106ck1560 FIND v(dout0_106) AT=785.025n

.meas tran vdout0_107ck1560 FIND v(dout0_107) AT=785.025n

.meas tran vdout0_108ck1560 FIND v(dout0_108) AT=785.025n

.meas tran vdout0_109ck1560 FIND v(dout0_109) AT=785.025n

.meas tran vdout0_110ck1560 FIND v(dout0_110) AT=785.025n

.meas tran vdout0_111ck1560 FIND v(dout0_111) AT=785.025n

.meas tran vdout0_112ck1560 FIND v(dout0_112) AT=785.025n

.meas tran vdout0_113ck1560 FIND v(dout0_113) AT=785.025n

.meas tran vdout0_114ck1560 FIND v(dout0_114) AT=785.025n

.meas tran vdout0_115ck1560 FIND v(dout0_115) AT=785.025n

.meas tran vdout0_116ck1560 FIND v(dout0_116) AT=785.025n

.meas tran vdout0_117ck1560 FIND v(dout0_117) AT=785.025n

.meas tran vdout0_118ck1560 FIND v(dout0_118) AT=785.025n

.meas tran vdout0_119ck1560 FIND v(dout0_119) AT=785.025n

.meas tran vdout0_120ck1560 FIND v(dout0_120) AT=785.025n

.meas tran vdout0_121ck1560 FIND v(dout0_121) AT=785.025n

.meas tran vdout0_122ck1560 FIND v(dout0_122) AT=785.025n

.meas tran vdout0_123ck1560 FIND v(dout0_123) AT=785.025n

.meas tran vdout0_124ck1560 FIND v(dout0_124) AT=785.025n

.meas tran vdout0_125ck1560 FIND v(dout0_125) AT=785.025n

.meas tran vdout0_126ck1560 FIND v(dout0_126) AT=785.025n

.meas tran vdout0_127ck1560 FIND v(dout0_127) AT=785.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_0ck1650 FIND v(dout0_0) AT=830.025n

.meas tran vdout0_1ck1650 FIND v(dout0_1) AT=830.025n

.meas tran vdout0_2ck1650 FIND v(dout0_2) AT=830.025n

.meas tran vdout0_3ck1650 FIND v(dout0_3) AT=830.025n

.meas tran vdout0_4ck1650 FIND v(dout0_4) AT=830.025n

.meas tran vdout0_5ck1650 FIND v(dout0_5) AT=830.025n

.meas tran vdout0_6ck1650 FIND v(dout0_6) AT=830.025n

.meas tran vdout0_7ck1650 FIND v(dout0_7) AT=830.025n

.meas tran vdout0_8ck1650 FIND v(dout0_8) AT=830.025n

.meas tran vdout0_9ck1650 FIND v(dout0_9) AT=830.025n

.meas tran vdout0_10ck1650 FIND v(dout0_10) AT=830.025n

.meas tran vdout0_11ck1650 FIND v(dout0_11) AT=830.025n

.meas tran vdout0_12ck1650 FIND v(dout0_12) AT=830.025n

.meas tran vdout0_13ck1650 FIND v(dout0_13) AT=830.025n

.meas tran vdout0_14ck1650 FIND v(dout0_14) AT=830.025n

.meas tran vdout0_15ck1650 FIND v(dout0_15) AT=830.025n

.meas tran vdout0_16ck1650 FIND v(dout0_16) AT=830.025n

.meas tran vdout0_17ck1650 FIND v(dout0_17) AT=830.025n

.meas tran vdout0_18ck1650 FIND v(dout0_18) AT=830.025n

.meas tran vdout0_19ck1650 FIND v(dout0_19) AT=830.025n

.meas tran vdout0_20ck1650 FIND v(dout0_20) AT=830.025n

.meas tran vdout0_21ck1650 FIND v(dout0_21) AT=830.025n

.meas tran vdout0_22ck1650 FIND v(dout0_22) AT=830.025n

.meas tran vdout0_23ck1650 FIND v(dout0_23) AT=830.025n

.meas tran vdout0_24ck1650 FIND v(dout0_24) AT=830.025n

.meas tran vdout0_25ck1650 FIND v(dout0_25) AT=830.025n

.meas tran vdout0_26ck1650 FIND v(dout0_26) AT=830.025n

.meas tran vdout0_27ck1650 FIND v(dout0_27) AT=830.025n

.meas tran vdout0_28ck1650 FIND v(dout0_28) AT=830.025n

.meas tran vdout0_29ck1650 FIND v(dout0_29) AT=830.025n

.meas tran vdout0_30ck1650 FIND v(dout0_30) AT=830.025n

.meas tran vdout0_31ck1650 FIND v(dout0_31) AT=830.025n

.meas tran vdout0_32ck1650 FIND v(dout0_32) AT=830.025n

.meas tran vdout0_33ck1650 FIND v(dout0_33) AT=830.025n

.meas tran vdout0_34ck1650 FIND v(dout0_34) AT=830.025n

.meas tran vdout0_35ck1650 FIND v(dout0_35) AT=830.025n

.meas tran vdout0_36ck1650 FIND v(dout0_36) AT=830.025n

.meas tran vdout0_37ck1650 FIND v(dout0_37) AT=830.025n

.meas tran vdout0_38ck1650 FIND v(dout0_38) AT=830.025n

.meas tran vdout0_39ck1650 FIND v(dout0_39) AT=830.025n

.meas tran vdout0_40ck1650 FIND v(dout0_40) AT=830.025n

.meas tran vdout0_41ck1650 FIND v(dout0_41) AT=830.025n

.meas tran vdout0_42ck1650 FIND v(dout0_42) AT=830.025n

.meas tran vdout0_43ck1650 FIND v(dout0_43) AT=830.025n

.meas tran vdout0_44ck1650 FIND v(dout0_44) AT=830.025n

.meas tran vdout0_45ck1650 FIND v(dout0_45) AT=830.025n

.meas tran vdout0_46ck1650 FIND v(dout0_46) AT=830.025n

.meas tran vdout0_47ck1650 FIND v(dout0_47) AT=830.025n

.meas tran vdout0_48ck1650 FIND v(dout0_48) AT=830.025n

.meas tran vdout0_49ck1650 FIND v(dout0_49) AT=830.025n

.meas tran vdout0_50ck1650 FIND v(dout0_50) AT=830.025n

.meas tran vdout0_51ck1650 FIND v(dout0_51) AT=830.025n

.meas tran vdout0_52ck1650 FIND v(dout0_52) AT=830.025n

.meas tran vdout0_53ck1650 FIND v(dout0_53) AT=830.025n

.meas tran vdout0_54ck1650 FIND v(dout0_54) AT=830.025n

.meas tran vdout0_55ck1650 FIND v(dout0_55) AT=830.025n

.meas tran vdout0_56ck1650 FIND v(dout0_56) AT=830.025n

.meas tran vdout0_57ck1650 FIND v(dout0_57) AT=830.025n

.meas tran vdout0_58ck1650 FIND v(dout0_58) AT=830.025n

.meas tran vdout0_59ck1650 FIND v(dout0_59) AT=830.025n

.meas tran vdout0_60ck1650 FIND v(dout0_60) AT=830.025n

.meas tran vdout0_61ck1650 FIND v(dout0_61) AT=830.025n

.meas tran vdout0_62ck1650 FIND v(dout0_62) AT=830.025n

.meas tran vdout0_63ck1650 FIND v(dout0_63) AT=830.025n

.meas tran vdout0_64ck1650 FIND v(dout0_64) AT=830.025n

.meas tran vdout0_65ck1650 FIND v(dout0_65) AT=830.025n

.meas tran vdout0_66ck1650 FIND v(dout0_66) AT=830.025n

.meas tran vdout0_67ck1650 FIND v(dout0_67) AT=830.025n

.meas tran vdout0_68ck1650 FIND v(dout0_68) AT=830.025n

.meas tran vdout0_69ck1650 FIND v(dout0_69) AT=830.025n

.meas tran vdout0_70ck1650 FIND v(dout0_70) AT=830.025n

.meas tran vdout0_71ck1650 FIND v(dout0_71) AT=830.025n

.meas tran vdout0_72ck1650 FIND v(dout0_72) AT=830.025n

.meas tran vdout0_73ck1650 FIND v(dout0_73) AT=830.025n

.meas tran vdout0_74ck1650 FIND v(dout0_74) AT=830.025n

.meas tran vdout0_75ck1650 FIND v(dout0_75) AT=830.025n

.meas tran vdout0_76ck1650 FIND v(dout0_76) AT=830.025n

.meas tran vdout0_77ck1650 FIND v(dout0_77) AT=830.025n

.meas tran vdout0_78ck1650 FIND v(dout0_78) AT=830.025n

.meas tran vdout0_79ck1650 FIND v(dout0_79) AT=830.025n

.meas tran vdout0_80ck1650 FIND v(dout0_80) AT=830.025n

.meas tran vdout0_81ck1650 FIND v(dout0_81) AT=830.025n

.meas tran vdout0_82ck1650 FIND v(dout0_82) AT=830.025n

.meas tran vdout0_83ck1650 FIND v(dout0_83) AT=830.025n

.meas tran vdout0_84ck1650 FIND v(dout0_84) AT=830.025n

.meas tran vdout0_85ck1650 FIND v(dout0_85) AT=830.025n

.meas tran vdout0_86ck1650 FIND v(dout0_86) AT=830.025n

.meas tran vdout0_87ck1650 FIND v(dout0_87) AT=830.025n

.meas tran vdout0_88ck1650 FIND v(dout0_88) AT=830.025n

.meas tran vdout0_89ck1650 FIND v(dout0_89) AT=830.025n

.meas tran vdout0_90ck1650 FIND v(dout0_90) AT=830.025n

.meas tran vdout0_91ck1650 FIND v(dout0_91) AT=830.025n

.meas tran vdout0_92ck1650 FIND v(dout0_92) AT=830.025n

.meas tran vdout0_93ck1650 FIND v(dout0_93) AT=830.025n

.meas tran vdout0_94ck1650 FIND v(dout0_94) AT=830.025n

.meas tran vdout0_95ck1650 FIND v(dout0_95) AT=830.025n

.meas tran vdout0_96ck1650 FIND v(dout0_96) AT=830.025n

.meas tran vdout0_97ck1650 FIND v(dout0_97) AT=830.025n

.meas tran vdout0_98ck1650 FIND v(dout0_98) AT=830.025n

.meas tran vdout0_99ck1650 FIND v(dout0_99) AT=830.025n

.meas tran vdout0_100ck1650 FIND v(dout0_100) AT=830.025n

.meas tran vdout0_101ck1650 FIND v(dout0_101) AT=830.025n

.meas tran vdout0_102ck1650 FIND v(dout0_102) AT=830.025n

.meas tran vdout0_103ck1650 FIND v(dout0_103) AT=830.025n

.meas tran vdout0_104ck1650 FIND v(dout0_104) AT=830.025n

.meas tran vdout0_105ck1650 FIND v(dout0_105) AT=830.025n

.meas tran vdout0_106ck1650 FIND v(dout0_106) AT=830.025n

.meas tran vdout0_107ck1650 FIND v(dout0_107) AT=830.025n

.meas tran vdout0_108ck1650 FIND v(dout0_108) AT=830.025n

.meas tran vdout0_109ck1650 FIND v(dout0_109) AT=830.025n

.meas tran vdout0_110ck1650 FIND v(dout0_110) AT=830.025n

.meas tran vdout0_111ck1650 FIND v(dout0_111) AT=830.025n

.meas tran vdout0_112ck1650 FIND v(dout0_112) AT=830.025n

.meas tran vdout0_113ck1650 FIND v(dout0_113) AT=830.025n

.meas tran vdout0_114ck1650 FIND v(dout0_114) AT=830.025n

.meas tran vdout0_115ck1650 FIND v(dout0_115) AT=830.025n

.meas tran vdout0_116ck1650 FIND v(dout0_116) AT=830.025n

.meas tran vdout0_117ck1650 FIND v(dout0_117) AT=830.025n

.meas tran vdout0_118ck1650 FIND v(dout0_118) AT=830.025n

.meas tran vdout0_119ck1650 FIND v(dout0_119) AT=830.025n

.meas tran vdout0_120ck1650 FIND v(dout0_120) AT=830.025n

.meas tran vdout0_121ck1650 FIND v(dout0_121) AT=830.025n

.meas tran vdout0_122ck1650 FIND v(dout0_122) AT=830.025n

.meas tran vdout0_123ck1650 FIND v(dout0_123) AT=830.025n

.meas tran vdout0_124ck1650 FIND v(dout0_124) AT=830.025n

.meas tran vdout0_125ck1650 FIND v(dout0_125) AT=830.025n

.meas tran vdout0_126ck1650 FIND v(dout0_126) AT=830.025n

.meas tran vdout0_127ck1650 FIND v(dout0_127) AT=830.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_0ck1680 FIND v(dout0_0) AT=845.025n

.meas tran vdout0_1ck1680 FIND v(dout0_1) AT=845.025n

.meas tran vdout0_2ck1680 FIND v(dout0_2) AT=845.025n

.meas tran vdout0_3ck1680 FIND v(dout0_3) AT=845.025n

.meas tran vdout0_4ck1680 FIND v(dout0_4) AT=845.025n

.meas tran vdout0_5ck1680 FIND v(dout0_5) AT=845.025n

.meas tran vdout0_6ck1680 FIND v(dout0_6) AT=845.025n

.meas tran vdout0_7ck1680 FIND v(dout0_7) AT=845.025n

.meas tran vdout0_8ck1680 FIND v(dout0_8) AT=845.025n

.meas tran vdout0_9ck1680 FIND v(dout0_9) AT=845.025n

.meas tran vdout0_10ck1680 FIND v(dout0_10) AT=845.025n

.meas tran vdout0_11ck1680 FIND v(dout0_11) AT=845.025n

.meas tran vdout0_12ck1680 FIND v(dout0_12) AT=845.025n

.meas tran vdout0_13ck1680 FIND v(dout0_13) AT=845.025n

.meas tran vdout0_14ck1680 FIND v(dout0_14) AT=845.025n

.meas tran vdout0_15ck1680 FIND v(dout0_15) AT=845.025n

.meas tran vdout0_16ck1680 FIND v(dout0_16) AT=845.025n

.meas tran vdout0_17ck1680 FIND v(dout0_17) AT=845.025n

.meas tran vdout0_18ck1680 FIND v(dout0_18) AT=845.025n

.meas tran vdout0_19ck1680 FIND v(dout0_19) AT=845.025n

.meas tran vdout0_20ck1680 FIND v(dout0_20) AT=845.025n

.meas tran vdout0_21ck1680 FIND v(dout0_21) AT=845.025n

.meas tran vdout0_22ck1680 FIND v(dout0_22) AT=845.025n

.meas tran vdout0_23ck1680 FIND v(dout0_23) AT=845.025n

.meas tran vdout0_24ck1680 FIND v(dout0_24) AT=845.025n

.meas tran vdout0_25ck1680 FIND v(dout0_25) AT=845.025n

.meas tran vdout0_26ck1680 FIND v(dout0_26) AT=845.025n

.meas tran vdout0_27ck1680 FIND v(dout0_27) AT=845.025n

.meas tran vdout0_28ck1680 FIND v(dout0_28) AT=845.025n

.meas tran vdout0_29ck1680 FIND v(dout0_29) AT=845.025n

.meas tran vdout0_30ck1680 FIND v(dout0_30) AT=845.025n

.meas tran vdout0_31ck1680 FIND v(dout0_31) AT=845.025n

.meas tran vdout0_32ck1680 FIND v(dout0_32) AT=845.025n

.meas tran vdout0_33ck1680 FIND v(dout0_33) AT=845.025n

.meas tran vdout0_34ck1680 FIND v(dout0_34) AT=845.025n

.meas tran vdout0_35ck1680 FIND v(dout0_35) AT=845.025n

.meas tran vdout0_36ck1680 FIND v(dout0_36) AT=845.025n

.meas tran vdout0_37ck1680 FIND v(dout0_37) AT=845.025n

.meas tran vdout0_38ck1680 FIND v(dout0_38) AT=845.025n

.meas tran vdout0_39ck1680 FIND v(dout0_39) AT=845.025n

.meas tran vdout0_40ck1680 FIND v(dout0_40) AT=845.025n

.meas tran vdout0_41ck1680 FIND v(dout0_41) AT=845.025n

.meas tran vdout0_42ck1680 FIND v(dout0_42) AT=845.025n

.meas tran vdout0_43ck1680 FIND v(dout0_43) AT=845.025n

.meas tran vdout0_44ck1680 FIND v(dout0_44) AT=845.025n

.meas tran vdout0_45ck1680 FIND v(dout0_45) AT=845.025n

.meas tran vdout0_46ck1680 FIND v(dout0_46) AT=845.025n

.meas tran vdout0_47ck1680 FIND v(dout0_47) AT=845.025n

.meas tran vdout0_48ck1680 FIND v(dout0_48) AT=845.025n

.meas tran vdout0_49ck1680 FIND v(dout0_49) AT=845.025n

.meas tran vdout0_50ck1680 FIND v(dout0_50) AT=845.025n

.meas tran vdout0_51ck1680 FIND v(dout0_51) AT=845.025n

.meas tran vdout0_52ck1680 FIND v(dout0_52) AT=845.025n

.meas tran vdout0_53ck1680 FIND v(dout0_53) AT=845.025n

.meas tran vdout0_54ck1680 FIND v(dout0_54) AT=845.025n

.meas tran vdout0_55ck1680 FIND v(dout0_55) AT=845.025n

.meas tran vdout0_56ck1680 FIND v(dout0_56) AT=845.025n

.meas tran vdout0_57ck1680 FIND v(dout0_57) AT=845.025n

.meas tran vdout0_58ck1680 FIND v(dout0_58) AT=845.025n

.meas tran vdout0_59ck1680 FIND v(dout0_59) AT=845.025n

.meas tran vdout0_60ck1680 FIND v(dout0_60) AT=845.025n

.meas tran vdout0_61ck1680 FIND v(dout0_61) AT=845.025n

.meas tran vdout0_62ck1680 FIND v(dout0_62) AT=845.025n

.meas tran vdout0_63ck1680 FIND v(dout0_63) AT=845.025n

.meas tran vdout0_64ck1680 FIND v(dout0_64) AT=845.025n

.meas tran vdout0_65ck1680 FIND v(dout0_65) AT=845.025n

.meas tran vdout0_66ck1680 FIND v(dout0_66) AT=845.025n

.meas tran vdout0_67ck1680 FIND v(dout0_67) AT=845.025n

.meas tran vdout0_68ck1680 FIND v(dout0_68) AT=845.025n

.meas tran vdout0_69ck1680 FIND v(dout0_69) AT=845.025n

.meas tran vdout0_70ck1680 FIND v(dout0_70) AT=845.025n

.meas tran vdout0_71ck1680 FIND v(dout0_71) AT=845.025n

.meas tran vdout0_72ck1680 FIND v(dout0_72) AT=845.025n

.meas tran vdout0_73ck1680 FIND v(dout0_73) AT=845.025n

.meas tran vdout0_74ck1680 FIND v(dout0_74) AT=845.025n

.meas tran vdout0_75ck1680 FIND v(dout0_75) AT=845.025n

.meas tran vdout0_76ck1680 FIND v(dout0_76) AT=845.025n

.meas tran vdout0_77ck1680 FIND v(dout0_77) AT=845.025n

.meas tran vdout0_78ck1680 FIND v(dout0_78) AT=845.025n

.meas tran vdout0_79ck1680 FIND v(dout0_79) AT=845.025n

.meas tran vdout0_80ck1680 FIND v(dout0_80) AT=845.025n

.meas tran vdout0_81ck1680 FIND v(dout0_81) AT=845.025n

.meas tran vdout0_82ck1680 FIND v(dout0_82) AT=845.025n

.meas tran vdout0_83ck1680 FIND v(dout0_83) AT=845.025n

.meas tran vdout0_84ck1680 FIND v(dout0_84) AT=845.025n

.meas tran vdout0_85ck1680 FIND v(dout0_85) AT=845.025n

.meas tran vdout0_86ck1680 FIND v(dout0_86) AT=845.025n

.meas tran vdout0_87ck1680 FIND v(dout0_87) AT=845.025n

.meas tran vdout0_88ck1680 FIND v(dout0_88) AT=845.025n

.meas tran vdout0_89ck1680 FIND v(dout0_89) AT=845.025n

.meas tran vdout0_90ck1680 FIND v(dout0_90) AT=845.025n

.meas tran vdout0_91ck1680 FIND v(dout0_91) AT=845.025n

.meas tran vdout0_92ck1680 FIND v(dout0_92) AT=845.025n

.meas tran vdout0_93ck1680 FIND v(dout0_93) AT=845.025n

.meas tran vdout0_94ck1680 FIND v(dout0_94) AT=845.025n

.meas tran vdout0_95ck1680 FIND v(dout0_95) AT=845.025n

.meas tran vdout0_96ck1680 FIND v(dout0_96) AT=845.025n

.meas tran vdout0_97ck1680 FIND v(dout0_97) AT=845.025n

.meas tran vdout0_98ck1680 FIND v(dout0_98) AT=845.025n

.meas tran vdout0_99ck1680 FIND v(dout0_99) AT=845.025n

.meas tran vdout0_100ck1680 FIND v(dout0_100) AT=845.025n

.meas tran vdout0_101ck1680 FIND v(dout0_101) AT=845.025n

.meas tran vdout0_102ck1680 FIND v(dout0_102) AT=845.025n

.meas tran vdout0_103ck1680 FIND v(dout0_103) AT=845.025n

.meas tran vdout0_104ck1680 FIND v(dout0_104) AT=845.025n

.meas tran vdout0_105ck1680 FIND v(dout0_105) AT=845.025n

.meas tran vdout0_106ck1680 FIND v(dout0_106) AT=845.025n

.meas tran vdout0_107ck1680 FIND v(dout0_107) AT=845.025n

.meas tran vdout0_108ck1680 FIND v(dout0_108) AT=845.025n

.meas tran vdout0_109ck1680 FIND v(dout0_109) AT=845.025n

.meas tran vdout0_110ck1680 FIND v(dout0_110) AT=845.025n

.meas tran vdout0_111ck1680 FIND v(dout0_111) AT=845.025n

.meas tran vdout0_112ck1680 FIND v(dout0_112) AT=845.025n

.meas tran vdout0_113ck1680 FIND v(dout0_113) AT=845.025n

.meas tran vdout0_114ck1680 FIND v(dout0_114) AT=845.025n

.meas tran vdout0_115ck1680 FIND v(dout0_115) AT=845.025n

.meas tran vdout0_116ck1680 FIND v(dout0_116) AT=845.025n

.meas tran vdout0_117ck1680 FIND v(dout0_117) AT=845.025n

.meas tran vdout0_118ck1680 FIND v(dout0_118) AT=845.025n

.meas tran vdout0_119ck1680 FIND v(dout0_119) AT=845.025n

.meas tran vdout0_120ck1680 FIND v(dout0_120) AT=845.025n

.meas tran vdout0_121ck1680 FIND v(dout0_121) AT=845.025n

.meas tran vdout0_122ck1680 FIND v(dout0_122) AT=845.025n

.meas tran vdout0_123ck1680 FIND v(dout0_123) AT=845.025n

.meas tran vdout0_124ck1680 FIND v(dout0_124) AT=845.025n

.meas tran vdout0_125ck1680 FIND v(dout0_125) AT=845.025n

.meas tran vdout0_126ck1680 FIND v(dout0_126) AT=845.025n

.meas tran vdout0_127ck1680 FIND v(dout0_127) AT=845.025n

.meas tran vdout0_0ck1700 FIND v(dout0_0) AT=855.025n

.meas tran vdout0_1ck1700 FIND v(dout0_1) AT=855.025n

.meas tran vdout0_2ck1700 FIND v(dout0_2) AT=855.025n

.meas tran vdout0_3ck1700 FIND v(dout0_3) AT=855.025n

.meas tran vdout0_4ck1700 FIND v(dout0_4) AT=855.025n

.meas tran vdout0_5ck1700 FIND v(dout0_5) AT=855.025n

.meas tran vdout0_6ck1700 FIND v(dout0_6) AT=855.025n

.meas tran vdout0_7ck1700 FIND v(dout0_7) AT=855.025n

.meas tran vdout0_8ck1700 FIND v(dout0_8) AT=855.025n

.meas tran vdout0_9ck1700 FIND v(dout0_9) AT=855.025n

.meas tran vdout0_10ck1700 FIND v(dout0_10) AT=855.025n

.meas tran vdout0_11ck1700 FIND v(dout0_11) AT=855.025n

.meas tran vdout0_12ck1700 FIND v(dout0_12) AT=855.025n

.meas tran vdout0_13ck1700 FIND v(dout0_13) AT=855.025n

.meas tran vdout0_14ck1700 FIND v(dout0_14) AT=855.025n

.meas tran vdout0_15ck1700 FIND v(dout0_15) AT=855.025n

.meas tran vdout0_16ck1700 FIND v(dout0_16) AT=855.025n

.meas tran vdout0_17ck1700 FIND v(dout0_17) AT=855.025n

.meas tran vdout0_18ck1700 FIND v(dout0_18) AT=855.025n

.meas tran vdout0_19ck1700 FIND v(dout0_19) AT=855.025n

.meas tran vdout0_20ck1700 FIND v(dout0_20) AT=855.025n

.meas tran vdout0_21ck1700 FIND v(dout0_21) AT=855.025n

.meas tran vdout0_22ck1700 FIND v(dout0_22) AT=855.025n

.meas tran vdout0_23ck1700 FIND v(dout0_23) AT=855.025n

.meas tran vdout0_24ck1700 FIND v(dout0_24) AT=855.025n

.meas tran vdout0_25ck1700 FIND v(dout0_25) AT=855.025n

.meas tran vdout0_26ck1700 FIND v(dout0_26) AT=855.025n

.meas tran vdout0_27ck1700 FIND v(dout0_27) AT=855.025n

.meas tran vdout0_28ck1700 FIND v(dout0_28) AT=855.025n

.meas tran vdout0_29ck1700 FIND v(dout0_29) AT=855.025n

.meas tran vdout0_30ck1700 FIND v(dout0_30) AT=855.025n

.meas tran vdout0_31ck1700 FIND v(dout0_31) AT=855.025n

.meas tran vdout0_32ck1700 FIND v(dout0_32) AT=855.025n

.meas tran vdout0_33ck1700 FIND v(dout0_33) AT=855.025n

.meas tran vdout0_34ck1700 FIND v(dout0_34) AT=855.025n

.meas tran vdout0_35ck1700 FIND v(dout0_35) AT=855.025n

.meas tran vdout0_36ck1700 FIND v(dout0_36) AT=855.025n

.meas tran vdout0_37ck1700 FIND v(dout0_37) AT=855.025n

.meas tran vdout0_38ck1700 FIND v(dout0_38) AT=855.025n

.meas tran vdout0_39ck1700 FIND v(dout0_39) AT=855.025n

.meas tran vdout0_40ck1700 FIND v(dout0_40) AT=855.025n

.meas tran vdout0_41ck1700 FIND v(dout0_41) AT=855.025n

.meas tran vdout0_42ck1700 FIND v(dout0_42) AT=855.025n

.meas tran vdout0_43ck1700 FIND v(dout0_43) AT=855.025n

.meas tran vdout0_44ck1700 FIND v(dout0_44) AT=855.025n

.meas tran vdout0_45ck1700 FIND v(dout0_45) AT=855.025n

.meas tran vdout0_46ck1700 FIND v(dout0_46) AT=855.025n

.meas tran vdout0_47ck1700 FIND v(dout0_47) AT=855.025n

.meas tran vdout0_48ck1700 FIND v(dout0_48) AT=855.025n

.meas tran vdout0_49ck1700 FIND v(dout0_49) AT=855.025n

.meas tran vdout0_50ck1700 FIND v(dout0_50) AT=855.025n

.meas tran vdout0_51ck1700 FIND v(dout0_51) AT=855.025n

.meas tran vdout0_52ck1700 FIND v(dout0_52) AT=855.025n

.meas tran vdout0_53ck1700 FIND v(dout0_53) AT=855.025n

.meas tran vdout0_54ck1700 FIND v(dout0_54) AT=855.025n

.meas tran vdout0_55ck1700 FIND v(dout0_55) AT=855.025n

.meas tran vdout0_56ck1700 FIND v(dout0_56) AT=855.025n

.meas tran vdout0_57ck1700 FIND v(dout0_57) AT=855.025n

.meas tran vdout0_58ck1700 FIND v(dout0_58) AT=855.025n

.meas tran vdout0_59ck1700 FIND v(dout0_59) AT=855.025n

.meas tran vdout0_60ck1700 FIND v(dout0_60) AT=855.025n

.meas tran vdout0_61ck1700 FIND v(dout0_61) AT=855.025n

.meas tran vdout0_62ck1700 FIND v(dout0_62) AT=855.025n

.meas tran vdout0_63ck1700 FIND v(dout0_63) AT=855.025n

.meas tran vdout0_64ck1700 FIND v(dout0_64) AT=855.025n

.meas tran vdout0_65ck1700 FIND v(dout0_65) AT=855.025n

.meas tran vdout0_66ck1700 FIND v(dout0_66) AT=855.025n

.meas tran vdout0_67ck1700 FIND v(dout0_67) AT=855.025n

.meas tran vdout0_68ck1700 FIND v(dout0_68) AT=855.025n

.meas tran vdout0_69ck1700 FIND v(dout0_69) AT=855.025n

.meas tran vdout0_70ck1700 FIND v(dout0_70) AT=855.025n

.meas tran vdout0_71ck1700 FIND v(dout0_71) AT=855.025n

.meas tran vdout0_72ck1700 FIND v(dout0_72) AT=855.025n

.meas tran vdout0_73ck1700 FIND v(dout0_73) AT=855.025n

.meas tran vdout0_74ck1700 FIND v(dout0_74) AT=855.025n

.meas tran vdout0_75ck1700 FIND v(dout0_75) AT=855.025n

.meas tran vdout0_76ck1700 FIND v(dout0_76) AT=855.025n

.meas tran vdout0_77ck1700 FIND v(dout0_77) AT=855.025n

.meas tran vdout0_78ck1700 FIND v(dout0_78) AT=855.025n

.meas tran vdout0_79ck1700 FIND v(dout0_79) AT=855.025n

.meas tran vdout0_80ck1700 FIND v(dout0_80) AT=855.025n

.meas tran vdout0_81ck1700 FIND v(dout0_81) AT=855.025n

.meas tran vdout0_82ck1700 FIND v(dout0_82) AT=855.025n

.meas tran vdout0_83ck1700 FIND v(dout0_83) AT=855.025n

.meas tran vdout0_84ck1700 FIND v(dout0_84) AT=855.025n

.meas tran vdout0_85ck1700 FIND v(dout0_85) AT=855.025n

.meas tran vdout0_86ck1700 FIND v(dout0_86) AT=855.025n

.meas tran vdout0_87ck1700 FIND v(dout0_87) AT=855.025n

.meas tran vdout0_88ck1700 FIND v(dout0_88) AT=855.025n

.meas tran vdout0_89ck1700 FIND v(dout0_89) AT=855.025n

.meas tran vdout0_90ck1700 FIND v(dout0_90) AT=855.025n

.meas tran vdout0_91ck1700 FIND v(dout0_91) AT=855.025n

.meas tran vdout0_92ck1700 FIND v(dout0_92) AT=855.025n

.meas tran vdout0_93ck1700 FIND v(dout0_93) AT=855.025n

.meas tran vdout0_94ck1700 FIND v(dout0_94) AT=855.025n

.meas tran vdout0_95ck1700 FIND v(dout0_95) AT=855.025n

.meas tran vdout0_96ck1700 FIND v(dout0_96) AT=855.025n

.meas tran vdout0_97ck1700 FIND v(dout0_97) AT=855.025n

.meas tran vdout0_98ck1700 FIND v(dout0_98) AT=855.025n

.meas tran vdout0_99ck1700 FIND v(dout0_99) AT=855.025n

.meas tran vdout0_100ck1700 FIND v(dout0_100) AT=855.025n

.meas tran vdout0_101ck1700 FIND v(dout0_101) AT=855.025n

.meas tran vdout0_102ck1700 FIND v(dout0_102) AT=855.025n

.meas tran vdout0_103ck1700 FIND v(dout0_103) AT=855.025n

.meas tran vdout0_104ck1700 FIND v(dout0_104) AT=855.025n

.meas tran vdout0_105ck1700 FIND v(dout0_105) AT=855.025n

.meas tran vdout0_106ck1700 FIND v(dout0_106) AT=855.025n

.meas tran vdout0_107ck1700 FIND v(dout0_107) AT=855.025n

.meas tran vdout0_108ck1700 FIND v(dout0_108) AT=855.025n

.meas tran vdout0_109ck1700 FIND v(dout0_109) AT=855.025n

.meas tran vdout0_110ck1700 FIND v(dout0_110) AT=855.025n

.meas tran vdout0_111ck1700 FIND v(dout0_111) AT=855.025n

.meas tran vdout0_112ck1700 FIND v(dout0_112) AT=855.025n

.meas tran vdout0_113ck1700 FIND v(dout0_113) AT=855.025n

.meas tran vdout0_114ck1700 FIND v(dout0_114) AT=855.025n

.meas tran vdout0_115ck1700 FIND v(dout0_115) AT=855.025n

.meas tran vdout0_116ck1700 FIND v(dout0_116) AT=855.025n

.meas tran vdout0_117ck1700 FIND v(dout0_117) AT=855.025n

.meas tran vdout0_118ck1700 FIND v(dout0_118) AT=855.025n

.meas tran vdout0_119ck1700 FIND v(dout0_119) AT=855.025n

.meas tran vdout0_120ck1700 FIND v(dout0_120) AT=855.025n

.meas tran vdout0_121ck1700 FIND v(dout0_121) AT=855.025n

.meas tran vdout0_122ck1700 FIND v(dout0_122) AT=855.025n

.meas tran vdout0_123ck1700 FIND v(dout0_123) AT=855.025n

.meas tran vdout0_124ck1700 FIND v(dout0_124) AT=855.025n

.meas tran vdout0_125ck1700 FIND v(dout0_125) AT=855.025n

.meas tran vdout0_126ck1700 FIND v(dout0_126) AT=855.025n

.meas tran vdout0_127ck1700 FIND v(dout0_127) AT=855.025n

.meas tran vdout0_0ck1750 FIND v(dout0_0) AT=880.025n

.meas tran vdout0_1ck1750 FIND v(dout0_1) AT=880.025n

.meas tran vdout0_2ck1750 FIND v(dout0_2) AT=880.025n

.meas tran vdout0_3ck1750 FIND v(dout0_3) AT=880.025n

.meas tran vdout0_4ck1750 FIND v(dout0_4) AT=880.025n

.meas tran vdout0_5ck1750 FIND v(dout0_5) AT=880.025n

.meas tran vdout0_6ck1750 FIND v(dout0_6) AT=880.025n

.meas tran vdout0_7ck1750 FIND v(dout0_7) AT=880.025n

.meas tran vdout0_8ck1750 FIND v(dout0_8) AT=880.025n

.meas tran vdout0_9ck1750 FIND v(dout0_9) AT=880.025n

.meas tran vdout0_10ck1750 FIND v(dout0_10) AT=880.025n

.meas tran vdout0_11ck1750 FIND v(dout0_11) AT=880.025n

.meas tran vdout0_12ck1750 FIND v(dout0_12) AT=880.025n

.meas tran vdout0_13ck1750 FIND v(dout0_13) AT=880.025n

.meas tran vdout0_14ck1750 FIND v(dout0_14) AT=880.025n

.meas tran vdout0_15ck1750 FIND v(dout0_15) AT=880.025n

.meas tran vdout0_16ck1750 FIND v(dout0_16) AT=880.025n

.meas tran vdout0_17ck1750 FIND v(dout0_17) AT=880.025n

.meas tran vdout0_18ck1750 FIND v(dout0_18) AT=880.025n

.meas tran vdout0_19ck1750 FIND v(dout0_19) AT=880.025n

.meas tran vdout0_20ck1750 FIND v(dout0_20) AT=880.025n

.meas tran vdout0_21ck1750 FIND v(dout0_21) AT=880.025n

.meas tran vdout0_22ck1750 FIND v(dout0_22) AT=880.025n

.meas tran vdout0_23ck1750 FIND v(dout0_23) AT=880.025n

.meas tran vdout0_24ck1750 FIND v(dout0_24) AT=880.025n

.meas tran vdout0_25ck1750 FIND v(dout0_25) AT=880.025n

.meas tran vdout0_26ck1750 FIND v(dout0_26) AT=880.025n

.meas tran vdout0_27ck1750 FIND v(dout0_27) AT=880.025n

.meas tran vdout0_28ck1750 FIND v(dout0_28) AT=880.025n

.meas tran vdout0_29ck1750 FIND v(dout0_29) AT=880.025n

.meas tran vdout0_30ck1750 FIND v(dout0_30) AT=880.025n

.meas tran vdout0_31ck1750 FIND v(dout0_31) AT=880.025n

.meas tran vdout0_32ck1750 FIND v(dout0_32) AT=880.025n

.meas tran vdout0_33ck1750 FIND v(dout0_33) AT=880.025n

.meas tran vdout0_34ck1750 FIND v(dout0_34) AT=880.025n

.meas tran vdout0_35ck1750 FIND v(dout0_35) AT=880.025n

.meas tran vdout0_36ck1750 FIND v(dout0_36) AT=880.025n

.meas tran vdout0_37ck1750 FIND v(dout0_37) AT=880.025n

.meas tran vdout0_38ck1750 FIND v(dout0_38) AT=880.025n

.meas tran vdout0_39ck1750 FIND v(dout0_39) AT=880.025n

.meas tran vdout0_40ck1750 FIND v(dout0_40) AT=880.025n

.meas tran vdout0_41ck1750 FIND v(dout0_41) AT=880.025n

.meas tran vdout0_42ck1750 FIND v(dout0_42) AT=880.025n

.meas tran vdout0_43ck1750 FIND v(dout0_43) AT=880.025n

.meas tran vdout0_44ck1750 FIND v(dout0_44) AT=880.025n

.meas tran vdout0_45ck1750 FIND v(dout0_45) AT=880.025n

.meas tran vdout0_46ck1750 FIND v(dout0_46) AT=880.025n

.meas tran vdout0_47ck1750 FIND v(dout0_47) AT=880.025n

.meas tran vdout0_48ck1750 FIND v(dout0_48) AT=880.025n

.meas tran vdout0_49ck1750 FIND v(dout0_49) AT=880.025n

.meas tran vdout0_50ck1750 FIND v(dout0_50) AT=880.025n

.meas tran vdout0_51ck1750 FIND v(dout0_51) AT=880.025n

.meas tran vdout0_52ck1750 FIND v(dout0_52) AT=880.025n

.meas tran vdout0_53ck1750 FIND v(dout0_53) AT=880.025n

.meas tran vdout0_54ck1750 FIND v(dout0_54) AT=880.025n

.meas tran vdout0_55ck1750 FIND v(dout0_55) AT=880.025n

.meas tran vdout0_56ck1750 FIND v(dout0_56) AT=880.025n

.meas tran vdout0_57ck1750 FIND v(dout0_57) AT=880.025n

.meas tran vdout0_58ck1750 FIND v(dout0_58) AT=880.025n

.meas tran vdout0_59ck1750 FIND v(dout0_59) AT=880.025n

.meas tran vdout0_60ck1750 FIND v(dout0_60) AT=880.025n

.meas tran vdout0_61ck1750 FIND v(dout0_61) AT=880.025n

.meas tran vdout0_62ck1750 FIND v(dout0_62) AT=880.025n

.meas tran vdout0_63ck1750 FIND v(dout0_63) AT=880.025n

.meas tran vdout0_64ck1750 FIND v(dout0_64) AT=880.025n

.meas tran vdout0_65ck1750 FIND v(dout0_65) AT=880.025n

.meas tran vdout0_66ck1750 FIND v(dout0_66) AT=880.025n

.meas tran vdout0_67ck1750 FIND v(dout0_67) AT=880.025n

.meas tran vdout0_68ck1750 FIND v(dout0_68) AT=880.025n

.meas tran vdout0_69ck1750 FIND v(dout0_69) AT=880.025n

.meas tran vdout0_70ck1750 FIND v(dout0_70) AT=880.025n

.meas tran vdout0_71ck1750 FIND v(dout0_71) AT=880.025n

.meas tran vdout0_72ck1750 FIND v(dout0_72) AT=880.025n

.meas tran vdout0_73ck1750 FIND v(dout0_73) AT=880.025n

.meas tran vdout0_74ck1750 FIND v(dout0_74) AT=880.025n

.meas tran vdout0_75ck1750 FIND v(dout0_75) AT=880.025n

.meas tran vdout0_76ck1750 FIND v(dout0_76) AT=880.025n

.meas tran vdout0_77ck1750 FIND v(dout0_77) AT=880.025n

.meas tran vdout0_78ck1750 FIND v(dout0_78) AT=880.025n

.meas tran vdout0_79ck1750 FIND v(dout0_79) AT=880.025n

.meas tran vdout0_80ck1750 FIND v(dout0_80) AT=880.025n

.meas tran vdout0_81ck1750 FIND v(dout0_81) AT=880.025n

.meas tran vdout0_82ck1750 FIND v(dout0_82) AT=880.025n

.meas tran vdout0_83ck1750 FIND v(dout0_83) AT=880.025n

.meas tran vdout0_84ck1750 FIND v(dout0_84) AT=880.025n

.meas tran vdout0_85ck1750 FIND v(dout0_85) AT=880.025n

.meas tran vdout0_86ck1750 FIND v(dout0_86) AT=880.025n

.meas tran vdout0_87ck1750 FIND v(dout0_87) AT=880.025n

.meas tran vdout0_88ck1750 FIND v(dout0_88) AT=880.025n

.meas tran vdout0_89ck1750 FIND v(dout0_89) AT=880.025n

.meas tran vdout0_90ck1750 FIND v(dout0_90) AT=880.025n

.meas tran vdout0_91ck1750 FIND v(dout0_91) AT=880.025n

.meas tran vdout0_92ck1750 FIND v(dout0_92) AT=880.025n

.meas tran vdout0_93ck1750 FIND v(dout0_93) AT=880.025n

.meas tran vdout0_94ck1750 FIND v(dout0_94) AT=880.025n

.meas tran vdout0_95ck1750 FIND v(dout0_95) AT=880.025n

.meas tran vdout0_96ck1750 FIND v(dout0_96) AT=880.025n

.meas tran vdout0_97ck1750 FIND v(dout0_97) AT=880.025n

.meas tran vdout0_98ck1750 FIND v(dout0_98) AT=880.025n

.meas tran vdout0_99ck1750 FIND v(dout0_99) AT=880.025n

.meas tran vdout0_100ck1750 FIND v(dout0_100) AT=880.025n

.meas tran vdout0_101ck1750 FIND v(dout0_101) AT=880.025n

.meas tran vdout0_102ck1750 FIND v(dout0_102) AT=880.025n

.meas tran vdout0_103ck1750 FIND v(dout0_103) AT=880.025n

.meas tran vdout0_104ck1750 FIND v(dout0_104) AT=880.025n

.meas tran vdout0_105ck1750 FIND v(dout0_105) AT=880.025n

.meas tran vdout0_106ck1750 FIND v(dout0_106) AT=880.025n

.meas tran vdout0_107ck1750 FIND v(dout0_107) AT=880.025n

.meas tran vdout0_108ck1750 FIND v(dout0_108) AT=880.025n

.meas tran vdout0_109ck1750 FIND v(dout0_109) AT=880.025n

.meas tran vdout0_110ck1750 FIND v(dout0_110) AT=880.025n

.meas tran vdout0_111ck1750 FIND v(dout0_111) AT=880.025n

.meas tran vdout0_112ck1750 FIND v(dout0_112) AT=880.025n

.meas tran vdout0_113ck1750 FIND v(dout0_113) AT=880.025n

.meas tran vdout0_114ck1750 FIND v(dout0_114) AT=880.025n

.meas tran vdout0_115ck1750 FIND v(dout0_115) AT=880.025n

.meas tran vdout0_116ck1750 FIND v(dout0_116) AT=880.025n

.meas tran vdout0_117ck1750 FIND v(dout0_117) AT=880.025n

.meas tran vdout0_118ck1750 FIND v(dout0_118) AT=880.025n

.meas tran vdout0_119ck1750 FIND v(dout0_119) AT=880.025n

.meas tran vdout0_120ck1750 FIND v(dout0_120) AT=880.025n

.meas tran vdout0_121ck1750 FIND v(dout0_121) AT=880.025n

.meas tran vdout0_122ck1750 FIND v(dout0_122) AT=880.025n

.meas tran vdout0_123ck1750 FIND v(dout0_123) AT=880.025n

.meas tran vdout0_124ck1750 FIND v(dout0_124) AT=880.025n

.meas tran vdout0_125ck1750 FIND v(dout0_125) AT=880.025n

.meas tran vdout0_126ck1750 FIND v(dout0_126) AT=880.025n

.meas tran vdout0_127ck1750 FIND v(dout0_127) AT=880.025n

.meas tran vdout0_0ck1780 FIND v(dout0_0) AT=895.025n

.meas tran vdout0_1ck1780 FIND v(dout0_1) AT=895.025n

.meas tran vdout0_2ck1780 FIND v(dout0_2) AT=895.025n

.meas tran vdout0_3ck1780 FIND v(dout0_3) AT=895.025n

.meas tran vdout0_4ck1780 FIND v(dout0_4) AT=895.025n

.meas tran vdout0_5ck1780 FIND v(dout0_5) AT=895.025n

.meas tran vdout0_6ck1780 FIND v(dout0_6) AT=895.025n

.meas tran vdout0_7ck1780 FIND v(dout0_7) AT=895.025n

.meas tran vdout0_8ck1780 FIND v(dout0_8) AT=895.025n

.meas tran vdout0_9ck1780 FIND v(dout0_9) AT=895.025n

.meas tran vdout0_10ck1780 FIND v(dout0_10) AT=895.025n

.meas tran vdout0_11ck1780 FIND v(dout0_11) AT=895.025n

.meas tran vdout0_12ck1780 FIND v(dout0_12) AT=895.025n

.meas tran vdout0_13ck1780 FIND v(dout0_13) AT=895.025n

.meas tran vdout0_14ck1780 FIND v(dout0_14) AT=895.025n

.meas tran vdout0_15ck1780 FIND v(dout0_15) AT=895.025n

.meas tran vdout0_16ck1780 FIND v(dout0_16) AT=895.025n

.meas tran vdout0_17ck1780 FIND v(dout0_17) AT=895.025n

.meas tran vdout0_18ck1780 FIND v(dout0_18) AT=895.025n

.meas tran vdout0_19ck1780 FIND v(dout0_19) AT=895.025n

.meas tran vdout0_20ck1780 FIND v(dout0_20) AT=895.025n

.meas tran vdout0_21ck1780 FIND v(dout0_21) AT=895.025n

.meas tran vdout0_22ck1780 FIND v(dout0_22) AT=895.025n

.meas tran vdout0_23ck1780 FIND v(dout0_23) AT=895.025n

.meas tran vdout0_24ck1780 FIND v(dout0_24) AT=895.025n

.meas tran vdout0_25ck1780 FIND v(dout0_25) AT=895.025n

.meas tran vdout0_26ck1780 FIND v(dout0_26) AT=895.025n

.meas tran vdout0_27ck1780 FIND v(dout0_27) AT=895.025n

.meas tran vdout0_28ck1780 FIND v(dout0_28) AT=895.025n

.meas tran vdout0_29ck1780 FIND v(dout0_29) AT=895.025n

.meas tran vdout0_30ck1780 FIND v(dout0_30) AT=895.025n

.meas tran vdout0_31ck1780 FIND v(dout0_31) AT=895.025n

.meas tran vdout0_32ck1780 FIND v(dout0_32) AT=895.025n

.meas tran vdout0_33ck1780 FIND v(dout0_33) AT=895.025n

.meas tran vdout0_34ck1780 FIND v(dout0_34) AT=895.025n

.meas tran vdout0_35ck1780 FIND v(dout0_35) AT=895.025n

.meas tran vdout0_36ck1780 FIND v(dout0_36) AT=895.025n

.meas tran vdout0_37ck1780 FIND v(dout0_37) AT=895.025n

.meas tran vdout0_38ck1780 FIND v(dout0_38) AT=895.025n

.meas tran vdout0_39ck1780 FIND v(dout0_39) AT=895.025n

.meas tran vdout0_40ck1780 FIND v(dout0_40) AT=895.025n

.meas tran vdout0_41ck1780 FIND v(dout0_41) AT=895.025n

.meas tran vdout0_42ck1780 FIND v(dout0_42) AT=895.025n

.meas tran vdout0_43ck1780 FIND v(dout0_43) AT=895.025n

.meas tran vdout0_44ck1780 FIND v(dout0_44) AT=895.025n

.meas tran vdout0_45ck1780 FIND v(dout0_45) AT=895.025n

.meas tran vdout0_46ck1780 FIND v(dout0_46) AT=895.025n

.meas tran vdout0_47ck1780 FIND v(dout0_47) AT=895.025n

.meas tran vdout0_48ck1780 FIND v(dout0_48) AT=895.025n

.meas tran vdout0_49ck1780 FIND v(dout0_49) AT=895.025n

.meas tran vdout0_50ck1780 FIND v(dout0_50) AT=895.025n

.meas tran vdout0_51ck1780 FIND v(dout0_51) AT=895.025n

.meas tran vdout0_52ck1780 FIND v(dout0_52) AT=895.025n

.meas tran vdout0_53ck1780 FIND v(dout0_53) AT=895.025n

.meas tran vdout0_54ck1780 FIND v(dout0_54) AT=895.025n

.meas tran vdout0_55ck1780 FIND v(dout0_55) AT=895.025n

.meas tran vdout0_56ck1780 FIND v(dout0_56) AT=895.025n

.meas tran vdout0_57ck1780 FIND v(dout0_57) AT=895.025n

.meas tran vdout0_58ck1780 FIND v(dout0_58) AT=895.025n

.meas tran vdout0_59ck1780 FIND v(dout0_59) AT=895.025n

.meas tran vdout0_60ck1780 FIND v(dout0_60) AT=895.025n

.meas tran vdout0_61ck1780 FIND v(dout0_61) AT=895.025n

.meas tran vdout0_62ck1780 FIND v(dout0_62) AT=895.025n

.meas tran vdout0_63ck1780 FIND v(dout0_63) AT=895.025n

.meas tran vdout0_64ck1780 FIND v(dout0_64) AT=895.025n

.meas tran vdout0_65ck1780 FIND v(dout0_65) AT=895.025n

.meas tran vdout0_66ck1780 FIND v(dout0_66) AT=895.025n

.meas tran vdout0_67ck1780 FIND v(dout0_67) AT=895.025n

.meas tran vdout0_68ck1780 FIND v(dout0_68) AT=895.025n

.meas tran vdout0_69ck1780 FIND v(dout0_69) AT=895.025n

.meas tran vdout0_70ck1780 FIND v(dout0_70) AT=895.025n

.meas tran vdout0_71ck1780 FIND v(dout0_71) AT=895.025n

.meas tran vdout0_72ck1780 FIND v(dout0_72) AT=895.025n

.meas tran vdout0_73ck1780 FIND v(dout0_73) AT=895.025n

.meas tran vdout0_74ck1780 FIND v(dout0_74) AT=895.025n

.meas tran vdout0_75ck1780 FIND v(dout0_75) AT=895.025n

.meas tran vdout0_76ck1780 FIND v(dout0_76) AT=895.025n

.meas tran vdout0_77ck1780 FIND v(dout0_77) AT=895.025n

.meas tran vdout0_78ck1780 FIND v(dout0_78) AT=895.025n

.meas tran vdout0_79ck1780 FIND v(dout0_79) AT=895.025n

.meas tran vdout0_80ck1780 FIND v(dout0_80) AT=895.025n

.meas tran vdout0_81ck1780 FIND v(dout0_81) AT=895.025n

.meas tran vdout0_82ck1780 FIND v(dout0_82) AT=895.025n

.meas tran vdout0_83ck1780 FIND v(dout0_83) AT=895.025n

.meas tran vdout0_84ck1780 FIND v(dout0_84) AT=895.025n

.meas tran vdout0_85ck1780 FIND v(dout0_85) AT=895.025n

.meas tran vdout0_86ck1780 FIND v(dout0_86) AT=895.025n

.meas tran vdout0_87ck1780 FIND v(dout0_87) AT=895.025n

.meas tran vdout0_88ck1780 FIND v(dout0_88) AT=895.025n

.meas tran vdout0_89ck1780 FIND v(dout0_89) AT=895.025n

.meas tran vdout0_90ck1780 FIND v(dout0_90) AT=895.025n

.meas tran vdout0_91ck1780 FIND v(dout0_91) AT=895.025n

.meas tran vdout0_92ck1780 FIND v(dout0_92) AT=895.025n

.meas tran vdout0_93ck1780 FIND v(dout0_93) AT=895.025n

.meas tran vdout0_94ck1780 FIND v(dout0_94) AT=895.025n

.meas tran vdout0_95ck1780 FIND v(dout0_95) AT=895.025n

.meas tran vdout0_96ck1780 FIND v(dout0_96) AT=895.025n

.meas tran vdout0_97ck1780 FIND v(dout0_97) AT=895.025n

.meas tran vdout0_98ck1780 FIND v(dout0_98) AT=895.025n

.meas tran vdout0_99ck1780 FIND v(dout0_99) AT=895.025n

.meas tran vdout0_100ck1780 FIND v(dout0_100) AT=895.025n

.meas tran vdout0_101ck1780 FIND v(dout0_101) AT=895.025n

.meas tran vdout0_102ck1780 FIND v(dout0_102) AT=895.025n

.meas tran vdout0_103ck1780 FIND v(dout0_103) AT=895.025n

.meas tran vdout0_104ck1780 FIND v(dout0_104) AT=895.025n

.meas tran vdout0_105ck1780 FIND v(dout0_105) AT=895.025n

.meas tran vdout0_106ck1780 FIND v(dout0_106) AT=895.025n

.meas tran vdout0_107ck1780 FIND v(dout0_107) AT=895.025n

.meas tran vdout0_108ck1780 FIND v(dout0_108) AT=895.025n

.meas tran vdout0_109ck1780 FIND v(dout0_109) AT=895.025n

.meas tran vdout0_110ck1780 FIND v(dout0_110) AT=895.025n

.meas tran vdout0_111ck1780 FIND v(dout0_111) AT=895.025n

.meas tran vdout0_112ck1780 FIND v(dout0_112) AT=895.025n

.meas tran vdout0_113ck1780 FIND v(dout0_113) AT=895.025n

.meas tran vdout0_114ck1780 FIND v(dout0_114) AT=895.025n

.meas tran vdout0_115ck1780 FIND v(dout0_115) AT=895.025n

.meas tran vdout0_116ck1780 FIND v(dout0_116) AT=895.025n

.meas tran vdout0_117ck1780 FIND v(dout0_117) AT=895.025n

.meas tran vdout0_118ck1780 FIND v(dout0_118) AT=895.025n

.meas tran vdout0_119ck1780 FIND v(dout0_119) AT=895.025n

.meas tran vdout0_120ck1780 FIND v(dout0_120) AT=895.025n

.meas tran vdout0_121ck1780 FIND v(dout0_121) AT=895.025n

.meas tran vdout0_122ck1780 FIND v(dout0_122) AT=895.025n

.meas tran vdout0_123ck1780 FIND v(dout0_123) AT=895.025n

.meas tran vdout0_124ck1780 FIND v(dout0_124) AT=895.025n

.meas tran vdout0_125ck1780 FIND v(dout0_125) AT=895.025n

.meas tran vdout0_126ck1780 FIND v(dout0_126) AT=895.025n

.meas tran vdout0_127ck1780 FIND v(dout0_127) AT=895.025n

.meas tran vdout0_0ck1800 FIND v(dout0_0) AT=905.025n

.meas tran vdout0_1ck1800 FIND v(dout0_1) AT=905.025n

.meas tran vdout0_2ck1800 FIND v(dout0_2) AT=905.025n

.meas tran vdout0_3ck1800 FIND v(dout0_3) AT=905.025n

.meas tran vdout0_4ck1800 FIND v(dout0_4) AT=905.025n

.meas tran vdout0_5ck1800 FIND v(dout0_5) AT=905.025n

.meas tran vdout0_6ck1800 FIND v(dout0_6) AT=905.025n

.meas tran vdout0_7ck1800 FIND v(dout0_7) AT=905.025n

.meas tran vdout0_8ck1800 FIND v(dout0_8) AT=905.025n

.meas tran vdout0_9ck1800 FIND v(dout0_9) AT=905.025n

.meas tran vdout0_10ck1800 FIND v(dout0_10) AT=905.025n

.meas tran vdout0_11ck1800 FIND v(dout0_11) AT=905.025n

.meas tran vdout0_12ck1800 FIND v(dout0_12) AT=905.025n

.meas tran vdout0_13ck1800 FIND v(dout0_13) AT=905.025n

.meas tran vdout0_14ck1800 FIND v(dout0_14) AT=905.025n

.meas tran vdout0_15ck1800 FIND v(dout0_15) AT=905.025n

.meas tran vdout0_16ck1800 FIND v(dout0_16) AT=905.025n

.meas tran vdout0_17ck1800 FIND v(dout0_17) AT=905.025n

.meas tran vdout0_18ck1800 FIND v(dout0_18) AT=905.025n

.meas tran vdout0_19ck1800 FIND v(dout0_19) AT=905.025n

.meas tran vdout0_20ck1800 FIND v(dout0_20) AT=905.025n

.meas tran vdout0_21ck1800 FIND v(dout0_21) AT=905.025n

.meas tran vdout0_22ck1800 FIND v(dout0_22) AT=905.025n

.meas tran vdout0_23ck1800 FIND v(dout0_23) AT=905.025n

.meas tran vdout0_24ck1800 FIND v(dout0_24) AT=905.025n

.meas tran vdout0_25ck1800 FIND v(dout0_25) AT=905.025n

.meas tran vdout0_26ck1800 FIND v(dout0_26) AT=905.025n

.meas tran vdout0_27ck1800 FIND v(dout0_27) AT=905.025n

.meas tran vdout0_28ck1800 FIND v(dout0_28) AT=905.025n

.meas tran vdout0_29ck1800 FIND v(dout0_29) AT=905.025n

.meas tran vdout0_30ck1800 FIND v(dout0_30) AT=905.025n

.meas tran vdout0_31ck1800 FIND v(dout0_31) AT=905.025n

.meas tran vdout0_32ck1800 FIND v(dout0_32) AT=905.025n

.meas tran vdout0_33ck1800 FIND v(dout0_33) AT=905.025n

.meas tran vdout0_34ck1800 FIND v(dout0_34) AT=905.025n

.meas tran vdout0_35ck1800 FIND v(dout0_35) AT=905.025n

.meas tran vdout0_36ck1800 FIND v(dout0_36) AT=905.025n

.meas tran vdout0_37ck1800 FIND v(dout0_37) AT=905.025n

.meas tran vdout0_38ck1800 FIND v(dout0_38) AT=905.025n

.meas tran vdout0_39ck1800 FIND v(dout0_39) AT=905.025n

.meas tran vdout0_40ck1800 FIND v(dout0_40) AT=905.025n

.meas tran vdout0_41ck1800 FIND v(dout0_41) AT=905.025n

.meas tran vdout0_42ck1800 FIND v(dout0_42) AT=905.025n

.meas tran vdout0_43ck1800 FIND v(dout0_43) AT=905.025n

.meas tran vdout0_44ck1800 FIND v(dout0_44) AT=905.025n

.meas tran vdout0_45ck1800 FIND v(dout0_45) AT=905.025n

.meas tran vdout0_46ck1800 FIND v(dout0_46) AT=905.025n

.meas tran vdout0_47ck1800 FIND v(dout0_47) AT=905.025n

.meas tran vdout0_48ck1800 FIND v(dout0_48) AT=905.025n

.meas tran vdout0_49ck1800 FIND v(dout0_49) AT=905.025n

.meas tran vdout0_50ck1800 FIND v(dout0_50) AT=905.025n

.meas tran vdout0_51ck1800 FIND v(dout0_51) AT=905.025n

.meas tran vdout0_52ck1800 FIND v(dout0_52) AT=905.025n

.meas tran vdout0_53ck1800 FIND v(dout0_53) AT=905.025n

.meas tran vdout0_54ck1800 FIND v(dout0_54) AT=905.025n

.meas tran vdout0_55ck1800 FIND v(dout0_55) AT=905.025n

.meas tran vdout0_56ck1800 FIND v(dout0_56) AT=905.025n

.meas tran vdout0_57ck1800 FIND v(dout0_57) AT=905.025n

.meas tran vdout0_58ck1800 FIND v(dout0_58) AT=905.025n

.meas tran vdout0_59ck1800 FIND v(dout0_59) AT=905.025n

.meas tran vdout0_60ck1800 FIND v(dout0_60) AT=905.025n

.meas tran vdout0_61ck1800 FIND v(dout0_61) AT=905.025n

.meas tran vdout0_62ck1800 FIND v(dout0_62) AT=905.025n

.meas tran vdout0_63ck1800 FIND v(dout0_63) AT=905.025n

.meas tran vdout0_64ck1800 FIND v(dout0_64) AT=905.025n

.meas tran vdout0_65ck1800 FIND v(dout0_65) AT=905.025n

.meas tran vdout0_66ck1800 FIND v(dout0_66) AT=905.025n

.meas tran vdout0_67ck1800 FIND v(dout0_67) AT=905.025n

.meas tran vdout0_68ck1800 FIND v(dout0_68) AT=905.025n

.meas tran vdout0_69ck1800 FIND v(dout0_69) AT=905.025n

.meas tran vdout0_70ck1800 FIND v(dout0_70) AT=905.025n

.meas tran vdout0_71ck1800 FIND v(dout0_71) AT=905.025n

.meas tran vdout0_72ck1800 FIND v(dout0_72) AT=905.025n

.meas tran vdout0_73ck1800 FIND v(dout0_73) AT=905.025n

.meas tran vdout0_74ck1800 FIND v(dout0_74) AT=905.025n

.meas tran vdout0_75ck1800 FIND v(dout0_75) AT=905.025n

.meas tran vdout0_76ck1800 FIND v(dout0_76) AT=905.025n

.meas tran vdout0_77ck1800 FIND v(dout0_77) AT=905.025n

.meas tran vdout0_78ck1800 FIND v(dout0_78) AT=905.025n

.meas tran vdout0_79ck1800 FIND v(dout0_79) AT=905.025n

.meas tran vdout0_80ck1800 FIND v(dout0_80) AT=905.025n

.meas tran vdout0_81ck1800 FIND v(dout0_81) AT=905.025n

.meas tran vdout0_82ck1800 FIND v(dout0_82) AT=905.025n

.meas tran vdout0_83ck1800 FIND v(dout0_83) AT=905.025n

.meas tran vdout0_84ck1800 FIND v(dout0_84) AT=905.025n

.meas tran vdout0_85ck1800 FIND v(dout0_85) AT=905.025n

.meas tran vdout0_86ck1800 FIND v(dout0_86) AT=905.025n

.meas tran vdout0_87ck1800 FIND v(dout0_87) AT=905.025n

.meas tran vdout0_88ck1800 FIND v(dout0_88) AT=905.025n

.meas tran vdout0_89ck1800 FIND v(dout0_89) AT=905.025n

.meas tran vdout0_90ck1800 FIND v(dout0_90) AT=905.025n

.meas tran vdout0_91ck1800 FIND v(dout0_91) AT=905.025n

.meas tran vdout0_92ck1800 FIND v(dout0_92) AT=905.025n

.meas tran vdout0_93ck1800 FIND v(dout0_93) AT=905.025n

.meas tran vdout0_94ck1800 FIND v(dout0_94) AT=905.025n

.meas tran vdout0_95ck1800 FIND v(dout0_95) AT=905.025n

.meas tran vdout0_96ck1800 FIND v(dout0_96) AT=905.025n

.meas tran vdout0_97ck1800 FIND v(dout0_97) AT=905.025n

.meas tran vdout0_98ck1800 FIND v(dout0_98) AT=905.025n

.meas tran vdout0_99ck1800 FIND v(dout0_99) AT=905.025n

.meas tran vdout0_100ck1800 FIND v(dout0_100) AT=905.025n

.meas tran vdout0_101ck1800 FIND v(dout0_101) AT=905.025n

.meas tran vdout0_102ck1800 FIND v(dout0_102) AT=905.025n

.meas tran vdout0_103ck1800 FIND v(dout0_103) AT=905.025n

.meas tran vdout0_104ck1800 FIND v(dout0_104) AT=905.025n

.meas tran vdout0_105ck1800 FIND v(dout0_105) AT=905.025n

.meas tran vdout0_106ck1800 FIND v(dout0_106) AT=905.025n

.meas tran vdout0_107ck1800 FIND v(dout0_107) AT=905.025n

.meas tran vdout0_108ck1800 FIND v(dout0_108) AT=905.025n

.meas tran vdout0_109ck1800 FIND v(dout0_109) AT=905.025n

.meas tran vdout0_110ck1800 FIND v(dout0_110) AT=905.025n

.meas tran vdout0_111ck1800 FIND v(dout0_111) AT=905.025n

.meas tran vdout0_112ck1800 FIND v(dout0_112) AT=905.025n

.meas tran vdout0_113ck1800 FIND v(dout0_113) AT=905.025n

.meas tran vdout0_114ck1800 FIND v(dout0_114) AT=905.025n

.meas tran vdout0_115ck1800 FIND v(dout0_115) AT=905.025n

.meas tran vdout0_116ck1800 FIND v(dout0_116) AT=905.025n

.meas tran vdout0_117ck1800 FIND v(dout0_117) AT=905.025n

.meas tran vdout0_118ck1800 FIND v(dout0_118) AT=905.025n

.meas tran vdout0_119ck1800 FIND v(dout0_119) AT=905.025n

.meas tran vdout0_120ck1800 FIND v(dout0_120) AT=905.025n

.meas tran vdout0_121ck1800 FIND v(dout0_121) AT=905.025n

.meas tran vdout0_122ck1800 FIND v(dout0_122) AT=905.025n

.meas tran vdout0_123ck1800 FIND v(dout0_123) AT=905.025n

.meas tran vdout0_124ck1800 FIND v(dout0_124) AT=905.025n

.meas tran vdout0_125ck1800 FIND v(dout0_125) AT=905.025n

.meas tran vdout0_126ck1800 FIND v(dout0_126) AT=905.025n

.meas tran vdout0_127ck1800 FIND v(dout0_127) AT=905.025n

.meas tran vdout0_0ck1810 FIND v(dout0_0) AT=910.025n

.meas tran vdout0_1ck1810 FIND v(dout0_1) AT=910.025n

.meas tran vdout0_2ck1810 FIND v(dout0_2) AT=910.025n

.meas tran vdout0_3ck1810 FIND v(dout0_3) AT=910.025n

.meas tran vdout0_4ck1810 FIND v(dout0_4) AT=910.025n

.meas tran vdout0_5ck1810 FIND v(dout0_5) AT=910.025n

.meas tran vdout0_6ck1810 FIND v(dout0_6) AT=910.025n

.meas tran vdout0_7ck1810 FIND v(dout0_7) AT=910.025n

.meas tran vdout0_8ck1810 FIND v(dout0_8) AT=910.025n

.meas tran vdout0_9ck1810 FIND v(dout0_9) AT=910.025n

.meas tran vdout0_10ck1810 FIND v(dout0_10) AT=910.025n

.meas tran vdout0_11ck1810 FIND v(dout0_11) AT=910.025n

.meas tran vdout0_12ck1810 FIND v(dout0_12) AT=910.025n

.meas tran vdout0_13ck1810 FIND v(dout0_13) AT=910.025n

.meas tran vdout0_14ck1810 FIND v(dout0_14) AT=910.025n

.meas tran vdout0_15ck1810 FIND v(dout0_15) AT=910.025n

.meas tran vdout0_16ck1810 FIND v(dout0_16) AT=910.025n

.meas tran vdout0_17ck1810 FIND v(dout0_17) AT=910.025n

.meas tran vdout0_18ck1810 FIND v(dout0_18) AT=910.025n

.meas tran vdout0_19ck1810 FIND v(dout0_19) AT=910.025n

.meas tran vdout0_20ck1810 FIND v(dout0_20) AT=910.025n

.meas tran vdout0_21ck1810 FIND v(dout0_21) AT=910.025n

.meas tran vdout0_22ck1810 FIND v(dout0_22) AT=910.025n

.meas tran vdout0_23ck1810 FIND v(dout0_23) AT=910.025n

.meas tran vdout0_24ck1810 FIND v(dout0_24) AT=910.025n

.meas tran vdout0_25ck1810 FIND v(dout0_25) AT=910.025n

.meas tran vdout0_26ck1810 FIND v(dout0_26) AT=910.025n

.meas tran vdout0_27ck1810 FIND v(dout0_27) AT=910.025n

.meas tran vdout0_28ck1810 FIND v(dout0_28) AT=910.025n

.meas tran vdout0_29ck1810 FIND v(dout0_29) AT=910.025n

.meas tran vdout0_30ck1810 FIND v(dout0_30) AT=910.025n

.meas tran vdout0_31ck1810 FIND v(dout0_31) AT=910.025n

.meas tran vdout0_32ck1810 FIND v(dout0_32) AT=910.025n

.meas tran vdout0_33ck1810 FIND v(dout0_33) AT=910.025n

.meas tran vdout0_34ck1810 FIND v(dout0_34) AT=910.025n

.meas tran vdout0_35ck1810 FIND v(dout0_35) AT=910.025n

.meas tran vdout0_36ck1810 FIND v(dout0_36) AT=910.025n

.meas tran vdout0_37ck1810 FIND v(dout0_37) AT=910.025n

.meas tran vdout0_38ck1810 FIND v(dout0_38) AT=910.025n

.meas tran vdout0_39ck1810 FIND v(dout0_39) AT=910.025n

.meas tran vdout0_40ck1810 FIND v(dout0_40) AT=910.025n

.meas tran vdout0_41ck1810 FIND v(dout0_41) AT=910.025n

.meas tran vdout0_42ck1810 FIND v(dout0_42) AT=910.025n

.meas tran vdout0_43ck1810 FIND v(dout0_43) AT=910.025n

.meas tran vdout0_44ck1810 FIND v(dout0_44) AT=910.025n

.meas tran vdout0_45ck1810 FIND v(dout0_45) AT=910.025n

.meas tran vdout0_46ck1810 FIND v(dout0_46) AT=910.025n

.meas tran vdout0_47ck1810 FIND v(dout0_47) AT=910.025n

.meas tran vdout0_48ck1810 FIND v(dout0_48) AT=910.025n

.meas tran vdout0_49ck1810 FIND v(dout0_49) AT=910.025n

.meas tran vdout0_50ck1810 FIND v(dout0_50) AT=910.025n

.meas tran vdout0_51ck1810 FIND v(dout0_51) AT=910.025n

.meas tran vdout0_52ck1810 FIND v(dout0_52) AT=910.025n

.meas tran vdout0_53ck1810 FIND v(dout0_53) AT=910.025n

.meas tran vdout0_54ck1810 FIND v(dout0_54) AT=910.025n

.meas tran vdout0_55ck1810 FIND v(dout0_55) AT=910.025n

.meas tran vdout0_56ck1810 FIND v(dout0_56) AT=910.025n

.meas tran vdout0_57ck1810 FIND v(dout0_57) AT=910.025n

.meas tran vdout0_58ck1810 FIND v(dout0_58) AT=910.025n

.meas tran vdout0_59ck1810 FIND v(dout0_59) AT=910.025n

.meas tran vdout0_60ck1810 FIND v(dout0_60) AT=910.025n

.meas tran vdout0_61ck1810 FIND v(dout0_61) AT=910.025n

.meas tran vdout0_62ck1810 FIND v(dout0_62) AT=910.025n

.meas tran vdout0_63ck1810 FIND v(dout0_63) AT=910.025n

.meas tran vdout0_64ck1810 FIND v(dout0_64) AT=910.025n

.meas tran vdout0_65ck1810 FIND v(dout0_65) AT=910.025n

.meas tran vdout0_66ck1810 FIND v(dout0_66) AT=910.025n

.meas tran vdout0_67ck1810 FIND v(dout0_67) AT=910.025n

.meas tran vdout0_68ck1810 FIND v(dout0_68) AT=910.025n

.meas tran vdout0_69ck1810 FIND v(dout0_69) AT=910.025n

.meas tran vdout0_70ck1810 FIND v(dout0_70) AT=910.025n

.meas tran vdout0_71ck1810 FIND v(dout0_71) AT=910.025n

.meas tran vdout0_72ck1810 FIND v(dout0_72) AT=910.025n

.meas tran vdout0_73ck1810 FIND v(dout0_73) AT=910.025n

.meas tran vdout0_74ck1810 FIND v(dout0_74) AT=910.025n

.meas tran vdout0_75ck1810 FIND v(dout0_75) AT=910.025n

.meas tran vdout0_76ck1810 FIND v(dout0_76) AT=910.025n

.meas tran vdout0_77ck1810 FIND v(dout0_77) AT=910.025n

.meas tran vdout0_78ck1810 FIND v(dout0_78) AT=910.025n

.meas tran vdout0_79ck1810 FIND v(dout0_79) AT=910.025n

.meas tran vdout0_80ck1810 FIND v(dout0_80) AT=910.025n

.meas tran vdout0_81ck1810 FIND v(dout0_81) AT=910.025n

.meas tran vdout0_82ck1810 FIND v(dout0_82) AT=910.025n

.meas tran vdout0_83ck1810 FIND v(dout0_83) AT=910.025n

.meas tran vdout0_84ck1810 FIND v(dout0_84) AT=910.025n

.meas tran vdout0_85ck1810 FIND v(dout0_85) AT=910.025n

.meas tran vdout0_86ck1810 FIND v(dout0_86) AT=910.025n

.meas tran vdout0_87ck1810 FIND v(dout0_87) AT=910.025n

.meas tran vdout0_88ck1810 FIND v(dout0_88) AT=910.025n

.meas tran vdout0_89ck1810 FIND v(dout0_89) AT=910.025n

.meas tran vdout0_90ck1810 FIND v(dout0_90) AT=910.025n

.meas tran vdout0_91ck1810 FIND v(dout0_91) AT=910.025n

.meas tran vdout0_92ck1810 FIND v(dout0_92) AT=910.025n

.meas tran vdout0_93ck1810 FIND v(dout0_93) AT=910.025n

.meas tran vdout0_94ck1810 FIND v(dout0_94) AT=910.025n

.meas tran vdout0_95ck1810 FIND v(dout0_95) AT=910.025n

.meas tran vdout0_96ck1810 FIND v(dout0_96) AT=910.025n

.meas tran vdout0_97ck1810 FIND v(dout0_97) AT=910.025n

.meas tran vdout0_98ck1810 FIND v(dout0_98) AT=910.025n

.meas tran vdout0_99ck1810 FIND v(dout0_99) AT=910.025n

.meas tran vdout0_100ck1810 FIND v(dout0_100) AT=910.025n

.meas tran vdout0_101ck1810 FIND v(dout0_101) AT=910.025n

.meas tran vdout0_102ck1810 FIND v(dout0_102) AT=910.025n

.meas tran vdout0_103ck1810 FIND v(dout0_103) AT=910.025n

.meas tran vdout0_104ck1810 FIND v(dout0_104) AT=910.025n

.meas tran vdout0_105ck1810 FIND v(dout0_105) AT=910.025n

.meas tran vdout0_106ck1810 FIND v(dout0_106) AT=910.025n

.meas tran vdout0_107ck1810 FIND v(dout0_107) AT=910.025n

.meas tran vdout0_108ck1810 FIND v(dout0_108) AT=910.025n

.meas tran vdout0_109ck1810 FIND v(dout0_109) AT=910.025n

.meas tran vdout0_110ck1810 FIND v(dout0_110) AT=910.025n

.meas tran vdout0_111ck1810 FIND v(dout0_111) AT=910.025n

.meas tran vdout0_112ck1810 FIND v(dout0_112) AT=910.025n

.meas tran vdout0_113ck1810 FIND v(dout0_113) AT=910.025n

.meas tran vdout0_114ck1810 FIND v(dout0_114) AT=910.025n

.meas tran vdout0_115ck1810 FIND v(dout0_115) AT=910.025n

.meas tran vdout0_116ck1810 FIND v(dout0_116) AT=910.025n

.meas tran vdout0_117ck1810 FIND v(dout0_117) AT=910.025n

.meas tran vdout0_118ck1810 FIND v(dout0_118) AT=910.025n

.meas tran vdout0_119ck1810 FIND v(dout0_119) AT=910.025n

.meas tran vdout0_120ck1810 FIND v(dout0_120) AT=910.025n

.meas tran vdout0_121ck1810 FIND v(dout0_121) AT=910.025n

.meas tran vdout0_122ck1810 FIND v(dout0_122) AT=910.025n

.meas tran vdout0_123ck1810 FIND v(dout0_123) AT=910.025n

.meas tran vdout0_124ck1810 FIND v(dout0_124) AT=910.025n

.meas tran vdout0_125ck1810 FIND v(dout0_125) AT=910.025n

.meas tran vdout0_126ck1810 FIND v(dout0_126) AT=910.025n

.meas tran vdout0_127ck1810 FIND v(dout0_127) AT=910.025n

.meas tran vdout0_0ck1820 FIND v(dout0_0) AT=915.025n

.meas tran vdout0_1ck1820 FIND v(dout0_1) AT=915.025n

.meas tran vdout0_2ck1820 FIND v(dout0_2) AT=915.025n

.meas tran vdout0_3ck1820 FIND v(dout0_3) AT=915.025n

.meas tran vdout0_4ck1820 FIND v(dout0_4) AT=915.025n

.meas tran vdout0_5ck1820 FIND v(dout0_5) AT=915.025n

.meas tran vdout0_6ck1820 FIND v(dout0_6) AT=915.025n

.meas tran vdout0_7ck1820 FIND v(dout0_7) AT=915.025n

.meas tran vdout0_8ck1820 FIND v(dout0_8) AT=915.025n

.meas tran vdout0_9ck1820 FIND v(dout0_9) AT=915.025n

.meas tran vdout0_10ck1820 FIND v(dout0_10) AT=915.025n

.meas tran vdout0_11ck1820 FIND v(dout0_11) AT=915.025n

.meas tran vdout0_12ck1820 FIND v(dout0_12) AT=915.025n

.meas tran vdout0_13ck1820 FIND v(dout0_13) AT=915.025n

.meas tran vdout0_14ck1820 FIND v(dout0_14) AT=915.025n

.meas tran vdout0_15ck1820 FIND v(dout0_15) AT=915.025n

.meas tran vdout0_16ck1820 FIND v(dout0_16) AT=915.025n

.meas tran vdout0_17ck1820 FIND v(dout0_17) AT=915.025n

.meas tran vdout0_18ck1820 FIND v(dout0_18) AT=915.025n

.meas tran vdout0_19ck1820 FIND v(dout0_19) AT=915.025n

.meas tran vdout0_20ck1820 FIND v(dout0_20) AT=915.025n

.meas tran vdout0_21ck1820 FIND v(dout0_21) AT=915.025n

.meas tran vdout0_22ck1820 FIND v(dout0_22) AT=915.025n

.meas tran vdout0_23ck1820 FIND v(dout0_23) AT=915.025n

.meas tran vdout0_24ck1820 FIND v(dout0_24) AT=915.025n

.meas tran vdout0_25ck1820 FIND v(dout0_25) AT=915.025n

.meas tran vdout0_26ck1820 FIND v(dout0_26) AT=915.025n

.meas tran vdout0_27ck1820 FIND v(dout0_27) AT=915.025n

.meas tran vdout0_28ck1820 FIND v(dout0_28) AT=915.025n

.meas tran vdout0_29ck1820 FIND v(dout0_29) AT=915.025n

.meas tran vdout0_30ck1820 FIND v(dout0_30) AT=915.025n

.meas tran vdout0_31ck1820 FIND v(dout0_31) AT=915.025n

.meas tran vdout0_32ck1820 FIND v(dout0_32) AT=915.025n

.meas tran vdout0_33ck1820 FIND v(dout0_33) AT=915.025n

.meas tran vdout0_34ck1820 FIND v(dout0_34) AT=915.025n

.meas tran vdout0_35ck1820 FIND v(dout0_35) AT=915.025n

.meas tran vdout0_36ck1820 FIND v(dout0_36) AT=915.025n

.meas tran vdout0_37ck1820 FIND v(dout0_37) AT=915.025n

.meas tran vdout0_38ck1820 FIND v(dout0_38) AT=915.025n

.meas tran vdout0_39ck1820 FIND v(dout0_39) AT=915.025n

.meas tran vdout0_40ck1820 FIND v(dout0_40) AT=915.025n

.meas tran vdout0_41ck1820 FIND v(dout0_41) AT=915.025n

.meas tran vdout0_42ck1820 FIND v(dout0_42) AT=915.025n

.meas tran vdout0_43ck1820 FIND v(dout0_43) AT=915.025n

.meas tran vdout0_44ck1820 FIND v(dout0_44) AT=915.025n

.meas tran vdout0_45ck1820 FIND v(dout0_45) AT=915.025n

.meas tran vdout0_46ck1820 FIND v(dout0_46) AT=915.025n

.meas tran vdout0_47ck1820 FIND v(dout0_47) AT=915.025n

.meas tran vdout0_48ck1820 FIND v(dout0_48) AT=915.025n

.meas tran vdout0_49ck1820 FIND v(dout0_49) AT=915.025n

.meas tran vdout0_50ck1820 FIND v(dout0_50) AT=915.025n

.meas tran vdout0_51ck1820 FIND v(dout0_51) AT=915.025n

.meas tran vdout0_52ck1820 FIND v(dout0_52) AT=915.025n

.meas tran vdout0_53ck1820 FIND v(dout0_53) AT=915.025n

.meas tran vdout0_54ck1820 FIND v(dout0_54) AT=915.025n

.meas tran vdout0_55ck1820 FIND v(dout0_55) AT=915.025n

.meas tran vdout0_56ck1820 FIND v(dout0_56) AT=915.025n

.meas tran vdout0_57ck1820 FIND v(dout0_57) AT=915.025n

.meas tran vdout0_58ck1820 FIND v(dout0_58) AT=915.025n

.meas tran vdout0_59ck1820 FIND v(dout0_59) AT=915.025n

.meas tran vdout0_60ck1820 FIND v(dout0_60) AT=915.025n

.meas tran vdout0_61ck1820 FIND v(dout0_61) AT=915.025n

.meas tran vdout0_62ck1820 FIND v(dout0_62) AT=915.025n

.meas tran vdout0_63ck1820 FIND v(dout0_63) AT=915.025n

.meas tran vdout0_64ck1820 FIND v(dout0_64) AT=915.025n

.meas tran vdout0_65ck1820 FIND v(dout0_65) AT=915.025n

.meas tran vdout0_66ck1820 FIND v(dout0_66) AT=915.025n

.meas tran vdout0_67ck1820 FIND v(dout0_67) AT=915.025n

.meas tran vdout0_68ck1820 FIND v(dout0_68) AT=915.025n

.meas tran vdout0_69ck1820 FIND v(dout0_69) AT=915.025n

.meas tran vdout0_70ck1820 FIND v(dout0_70) AT=915.025n

.meas tran vdout0_71ck1820 FIND v(dout0_71) AT=915.025n

.meas tran vdout0_72ck1820 FIND v(dout0_72) AT=915.025n

.meas tran vdout0_73ck1820 FIND v(dout0_73) AT=915.025n

.meas tran vdout0_74ck1820 FIND v(dout0_74) AT=915.025n

.meas tran vdout0_75ck1820 FIND v(dout0_75) AT=915.025n

.meas tran vdout0_76ck1820 FIND v(dout0_76) AT=915.025n

.meas tran vdout0_77ck1820 FIND v(dout0_77) AT=915.025n

.meas tran vdout0_78ck1820 FIND v(dout0_78) AT=915.025n

.meas tran vdout0_79ck1820 FIND v(dout0_79) AT=915.025n

.meas tran vdout0_80ck1820 FIND v(dout0_80) AT=915.025n

.meas tran vdout0_81ck1820 FIND v(dout0_81) AT=915.025n

.meas tran vdout0_82ck1820 FIND v(dout0_82) AT=915.025n

.meas tran vdout0_83ck1820 FIND v(dout0_83) AT=915.025n

.meas tran vdout0_84ck1820 FIND v(dout0_84) AT=915.025n

.meas tran vdout0_85ck1820 FIND v(dout0_85) AT=915.025n

.meas tran vdout0_86ck1820 FIND v(dout0_86) AT=915.025n

.meas tran vdout0_87ck1820 FIND v(dout0_87) AT=915.025n

.meas tran vdout0_88ck1820 FIND v(dout0_88) AT=915.025n

.meas tran vdout0_89ck1820 FIND v(dout0_89) AT=915.025n

.meas tran vdout0_90ck1820 FIND v(dout0_90) AT=915.025n

.meas tran vdout0_91ck1820 FIND v(dout0_91) AT=915.025n

.meas tran vdout0_92ck1820 FIND v(dout0_92) AT=915.025n

.meas tran vdout0_93ck1820 FIND v(dout0_93) AT=915.025n

.meas tran vdout0_94ck1820 FIND v(dout0_94) AT=915.025n

.meas tran vdout0_95ck1820 FIND v(dout0_95) AT=915.025n

.meas tran vdout0_96ck1820 FIND v(dout0_96) AT=915.025n

.meas tran vdout0_97ck1820 FIND v(dout0_97) AT=915.025n

.meas tran vdout0_98ck1820 FIND v(dout0_98) AT=915.025n

.meas tran vdout0_99ck1820 FIND v(dout0_99) AT=915.025n

.meas tran vdout0_100ck1820 FIND v(dout0_100) AT=915.025n

.meas tran vdout0_101ck1820 FIND v(dout0_101) AT=915.025n

.meas tran vdout0_102ck1820 FIND v(dout0_102) AT=915.025n

.meas tran vdout0_103ck1820 FIND v(dout0_103) AT=915.025n

.meas tran vdout0_104ck1820 FIND v(dout0_104) AT=915.025n

.meas tran vdout0_105ck1820 FIND v(dout0_105) AT=915.025n

.meas tran vdout0_106ck1820 FIND v(dout0_106) AT=915.025n

.meas tran vdout0_107ck1820 FIND v(dout0_107) AT=915.025n

.meas tran vdout0_108ck1820 FIND v(dout0_108) AT=915.025n

.meas tran vdout0_109ck1820 FIND v(dout0_109) AT=915.025n

.meas tran vdout0_110ck1820 FIND v(dout0_110) AT=915.025n

.meas tran vdout0_111ck1820 FIND v(dout0_111) AT=915.025n

.meas tran vdout0_112ck1820 FIND v(dout0_112) AT=915.025n

.meas tran vdout0_113ck1820 FIND v(dout0_113) AT=915.025n

.meas tran vdout0_114ck1820 FIND v(dout0_114) AT=915.025n

.meas tran vdout0_115ck1820 FIND v(dout0_115) AT=915.025n

.meas tran vdout0_116ck1820 FIND v(dout0_116) AT=915.025n

.meas tran vdout0_117ck1820 FIND v(dout0_117) AT=915.025n

.meas tran vdout0_118ck1820 FIND v(dout0_118) AT=915.025n

.meas tran vdout0_119ck1820 FIND v(dout0_119) AT=915.025n

.meas tran vdout0_120ck1820 FIND v(dout0_120) AT=915.025n

.meas tran vdout0_121ck1820 FIND v(dout0_121) AT=915.025n

.meas tran vdout0_122ck1820 FIND v(dout0_122) AT=915.025n

.meas tran vdout0_123ck1820 FIND v(dout0_123) AT=915.025n

.meas tran vdout0_124ck1820 FIND v(dout0_124) AT=915.025n

.meas tran vdout0_125ck1820 FIND v(dout0_125) AT=915.025n

.meas tran vdout0_126ck1820 FIND v(dout0_126) AT=915.025n

.meas tran vdout0_127ck1820 FIND v(dout0_127) AT=915.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_0ck1910 FIND v(dout0_0) AT=960.025n

.meas tran vdout0_1ck1910 FIND v(dout0_1) AT=960.025n

.meas tran vdout0_2ck1910 FIND v(dout0_2) AT=960.025n

.meas tran vdout0_3ck1910 FIND v(dout0_3) AT=960.025n

.meas tran vdout0_4ck1910 FIND v(dout0_4) AT=960.025n

.meas tran vdout0_5ck1910 FIND v(dout0_5) AT=960.025n

.meas tran vdout0_6ck1910 FIND v(dout0_6) AT=960.025n

.meas tran vdout0_7ck1910 FIND v(dout0_7) AT=960.025n

.meas tran vdout0_8ck1910 FIND v(dout0_8) AT=960.025n

.meas tran vdout0_9ck1910 FIND v(dout0_9) AT=960.025n

.meas tran vdout0_10ck1910 FIND v(dout0_10) AT=960.025n

.meas tran vdout0_11ck1910 FIND v(dout0_11) AT=960.025n

.meas tran vdout0_12ck1910 FIND v(dout0_12) AT=960.025n

.meas tran vdout0_13ck1910 FIND v(dout0_13) AT=960.025n

.meas tran vdout0_14ck1910 FIND v(dout0_14) AT=960.025n

.meas tran vdout0_15ck1910 FIND v(dout0_15) AT=960.025n

.meas tran vdout0_16ck1910 FIND v(dout0_16) AT=960.025n

.meas tran vdout0_17ck1910 FIND v(dout0_17) AT=960.025n

.meas tran vdout0_18ck1910 FIND v(dout0_18) AT=960.025n

.meas tran vdout0_19ck1910 FIND v(dout0_19) AT=960.025n

.meas tran vdout0_20ck1910 FIND v(dout0_20) AT=960.025n

.meas tran vdout0_21ck1910 FIND v(dout0_21) AT=960.025n

.meas tran vdout0_22ck1910 FIND v(dout0_22) AT=960.025n

.meas tran vdout0_23ck1910 FIND v(dout0_23) AT=960.025n

.meas tran vdout0_24ck1910 FIND v(dout0_24) AT=960.025n

.meas tran vdout0_25ck1910 FIND v(dout0_25) AT=960.025n

.meas tran vdout0_26ck1910 FIND v(dout0_26) AT=960.025n

.meas tran vdout0_27ck1910 FIND v(dout0_27) AT=960.025n

.meas tran vdout0_28ck1910 FIND v(dout0_28) AT=960.025n

.meas tran vdout0_29ck1910 FIND v(dout0_29) AT=960.025n

.meas tran vdout0_30ck1910 FIND v(dout0_30) AT=960.025n

.meas tran vdout0_31ck1910 FIND v(dout0_31) AT=960.025n

.meas tran vdout0_32ck1910 FIND v(dout0_32) AT=960.025n

.meas tran vdout0_33ck1910 FIND v(dout0_33) AT=960.025n

.meas tran vdout0_34ck1910 FIND v(dout0_34) AT=960.025n

.meas tran vdout0_35ck1910 FIND v(dout0_35) AT=960.025n

.meas tran vdout0_36ck1910 FIND v(dout0_36) AT=960.025n

.meas tran vdout0_37ck1910 FIND v(dout0_37) AT=960.025n

.meas tran vdout0_38ck1910 FIND v(dout0_38) AT=960.025n

.meas tran vdout0_39ck1910 FIND v(dout0_39) AT=960.025n

.meas tran vdout0_40ck1910 FIND v(dout0_40) AT=960.025n

.meas tran vdout0_41ck1910 FIND v(dout0_41) AT=960.025n

.meas tran vdout0_42ck1910 FIND v(dout0_42) AT=960.025n

.meas tran vdout0_43ck1910 FIND v(dout0_43) AT=960.025n

.meas tran vdout0_44ck1910 FIND v(dout0_44) AT=960.025n

.meas tran vdout0_45ck1910 FIND v(dout0_45) AT=960.025n

.meas tran vdout0_46ck1910 FIND v(dout0_46) AT=960.025n

.meas tran vdout0_47ck1910 FIND v(dout0_47) AT=960.025n

.meas tran vdout0_48ck1910 FIND v(dout0_48) AT=960.025n

.meas tran vdout0_49ck1910 FIND v(dout0_49) AT=960.025n

.meas tran vdout0_50ck1910 FIND v(dout0_50) AT=960.025n

.meas tran vdout0_51ck1910 FIND v(dout0_51) AT=960.025n

.meas tran vdout0_52ck1910 FIND v(dout0_52) AT=960.025n

.meas tran vdout0_53ck1910 FIND v(dout0_53) AT=960.025n

.meas tran vdout0_54ck1910 FIND v(dout0_54) AT=960.025n

.meas tran vdout0_55ck1910 FIND v(dout0_55) AT=960.025n

.meas tran vdout0_56ck1910 FIND v(dout0_56) AT=960.025n

.meas tran vdout0_57ck1910 FIND v(dout0_57) AT=960.025n

.meas tran vdout0_58ck1910 FIND v(dout0_58) AT=960.025n

.meas tran vdout0_59ck1910 FIND v(dout0_59) AT=960.025n

.meas tran vdout0_60ck1910 FIND v(dout0_60) AT=960.025n

.meas tran vdout0_61ck1910 FIND v(dout0_61) AT=960.025n

.meas tran vdout0_62ck1910 FIND v(dout0_62) AT=960.025n

.meas tran vdout0_63ck1910 FIND v(dout0_63) AT=960.025n

.meas tran vdout0_64ck1910 FIND v(dout0_64) AT=960.025n

.meas tran vdout0_65ck1910 FIND v(dout0_65) AT=960.025n

.meas tran vdout0_66ck1910 FIND v(dout0_66) AT=960.025n

.meas tran vdout0_67ck1910 FIND v(dout0_67) AT=960.025n

.meas tran vdout0_68ck1910 FIND v(dout0_68) AT=960.025n

.meas tran vdout0_69ck1910 FIND v(dout0_69) AT=960.025n

.meas tran vdout0_70ck1910 FIND v(dout0_70) AT=960.025n

.meas tran vdout0_71ck1910 FIND v(dout0_71) AT=960.025n

.meas tran vdout0_72ck1910 FIND v(dout0_72) AT=960.025n

.meas tran vdout0_73ck1910 FIND v(dout0_73) AT=960.025n

.meas tran vdout0_74ck1910 FIND v(dout0_74) AT=960.025n

.meas tran vdout0_75ck1910 FIND v(dout0_75) AT=960.025n

.meas tran vdout0_76ck1910 FIND v(dout0_76) AT=960.025n

.meas tran vdout0_77ck1910 FIND v(dout0_77) AT=960.025n

.meas tran vdout0_78ck1910 FIND v(dout0_78) AT=960.025n

.meas tran vdout0_79ck1910 FIND v(dout0_79) AT=960.025n

.meas tran vdout0_80ck1910 FIND v(dout0_80) AT=960.025n

.meas tran vdout0_81ck1910 FIND v(dout0_81) AT=960.025n

.meas tran vdout0_82ck1910 FIND v(dout0_82) AT=960.025n

.meas tran vdout0_83ck1910 FIND v(dout0_83) AT=960.025n

.meas tran vdout0_84ck1910 FIND v(dout0_84) AT=960.025n

.meas tran vdout0_85ck1910 FIND v(dout0_85) AT=960.025n

.meas tran vdout0_86ck1910 FIND v(dout0_86) AT=960.025n

.meas tran vdout0_87ck1910 FIND v(dout0_87) AT=960.025n

.meas tran vdout0_88ck1910 FIND v(dout0_88) AT=960.025n

.meas tran vdout0_89ck1910 FIND v(dout0_89) AT=960.025n

.meas tran vdout0_90ck1910 FIND v(dout0_90) AT=960.025n

.meas tran vdout0_91ck1910 FIND v(dout0_91) AT=960.025n

.meas tran vdout0_92ck1910 FIND v(dout0_92) AT=960.025n

.meas tran vdout0_93ck1910 FIND v(dout0_93) AT=960.025n

.meas tran vdout0_94ck1910 FIND v(dout0_94) AT=960.025n

.meas tran vdout0_95ck1910 FIND v(dout0_95) AT=960.025n

.meas tran vdout0_96ck1910 FIND v(dout0_96) AT=960.025n

.meas tran vdout0_97ck1910 FIND v(dout0_97) AT=960.025n

.meas tran vdout0_98ck1910 FIND v(dout0_98) AT=960.025n

.meas tran vdout0_99ck1910 FIND v(dout0_99) AT=960.025n

.meas tran vdout0_100ck1910 FIND v(dout0_100) AT=960.025n

.meas tran vdout0_101ck1910 FIND v(dout0_101) AT=960.025n

.meas tran vdout0_102ck1910 FIND v(dout0_102) AT=960.025n

.meas tran vdout0_103ck1910 FIND v(dout0_103) AT=960.025n

.meas tran vdout0_104ck1910 FIND v(dout0_104) AT=960.025n

.meas tran vdout0_105ck1910 FIND v(dout0_105) AT=960.025n

.meas tran vdout0_106ck1910 FIND v(dout0_106) AT=960.025n

.meas tran vdout0_107ck1910 FIND v(dout0_107) AT=960.025n

.meas tran vdout0_108ck1910 FIND v(dout0_108) AT=960.025n

.meas tran vdout0_109ck1910 FIND v(dout0_109) AT=960.025n

.meas tran vdout0_110ck1910 FIND v(dout0_110) AT=960.025n

.meas tran vdout0_111ck1910 FIND v(dout0_111) AT=960.025n

.meas tran vdout0_112ck1910 FIND v(dout0_112) AT=960.025n

.meas tran vdout0_113ck1910 FIND v(dout0_113) AT=960.025n

.meas tran vdout0_114ck1910 FIND v(dout0_114) AT=960.025n

.meas tran vdout0_115ck1910 FIND v(dout0_115) AT=960.025n

.meas tran vdout0_116ck1910 FIND v(dout0_116) AT=960.025n

.meas tran vdout0_117ck1910 FIND v(dout0_117) AT=960.025n

.meas tran vdout0_118ck1910 FIND v(dout0_118) AT=960.025n

.meas tran vdout0_119ck1910 FIND v(dout0_119) AT=960.025n

.meas tran vdout0_120ck1910 FIND v(dout0_120) AT=960.025n

.meas tran vdout0_121ck1910 FIND v(dout0_121) AT=960.025n

.meas tran vdout0_122ck1910 FIND v(dout0_122) AT=960.025n

.meas tran vdout0_123ck1910 FIND v(dout0_123) AT=960.025n

.meas tran vdout0_124ck1910 FIND v(dout0_124) AT=960.025n

.meas tran vdout0_125ck1910 FIND v(dout0_125) AT=960.025n

.meas tran vdout0_126ck1910 FIND v(dout0_126) AT=960.025n

.meas tran vdout0_127ck1910 FIND v(dout0_127) AT=960.025n

.meas tran vdout0_0ck1950 FIND v(dout0_0) AT=980.025n

.meas tran vdout0_1ck1950 FIND v(dout0_1) AT=980.025n

.meas tran vdout0_2ck1950 FIND v(dout0_2) AT=980.025n

.meas tran vdout0_3ck1950 FIND v(dout0_3) AT=980.025n

.meas tran vdout0_4ck1950 FIND v(dout0_4) AT=980.025n

.meas tran vdout0_5ck1950 FIND v(dout0_5) AT=980.025n

.meas tran vdout0_6ck1950 FIND v(dout0_6) AT=980.025n

.meas tran vdout0_7ck1950 FIND v(dout0_7) AT=980.025n

.meas tran vdout0_8ck1950 FIND v(dout0_8) AT=980.025n

.meas tran vdout0_9ck1950 FIND v(dout0_9) AT=980.025n

.meas tran vdout0_10ck1950 FIND v(dout0_10) AT=980.025n

.meas tran vdout0_11ck1950 FIND v(dout0_11) AT=980.025n

.meas tran vdout0_12ck1950 FIND v(dout0_12) AT=980.025n

.meas tran vdout0_13ck1950 FIND v(dout0_13) AT=980.025n

.meas tran vdout0_14ck1950 FIND v(dout0_14) AT=980.025n

.meas tran vdout0_15ck1950 FIND v(dout0_15) AT=980.025n

.meas tran vdout0_16ck1950 FIND v(dout0_16) AT=980.025n

.meas tran vdout0_17ck1950 FIND v(dout0_17) AT=980.025n

.meas tran vdout0_18ck1950 FIND v(dout0_18) AT=980.025n

.meas tran vdout0_19ck1950 FIND v(dout0_19) AT=980.025n

.meas tran vdout0_20ck1950 FIND v(dout0_20) AT=980.025n

.meas tran vdout0_21ck1950 FIND v(dout0_21) AT=980.025n

.meas tran vdout0_22ck1950 FIND v(dout0_22) AT=980.025n

.meas tran vdout0_23ck1950 FIND v(dout0_23) AT=980.025n

.meas tran vdout0_24ck1950 FIND v(dout0_24) AT=980.025n

.meas tran vdout0_25ck1950 FIND v(dout0_25) AT=980.025n

.meas tran vdout0_26ck1950 FIND v(dout0_26) AT=980.025n

.meas tran vdout0_27ck1950 FIND v(dout0_27) AT=980.025n

.meas tran vdout0_28ck1950 FIND v(dout0_28) AT=980.025n

.meas tran vdout0_29ck1950 FIND v(dout0_29) AT=980.025n

.meas tran vdout0_30ck1950 FIND v(dout0_30) AT=980.025n

.meas tran vdout0_31ck1950 FIND v(dout0_31) AT=980.025n

.meas tran vdout0_32ck1950 FIND v(dout0_32) AT=980.025n

.meas tran vdout0_33ck1950 FIND v(dout0_33) AT=980.025n

.meas tran vdout0_34ck1950 FIND v(dout0_34) AT=980.025n

.meas tran vdout0_35ck1950 FIND v(dout0_35) AT=980.025n

.meas tran vdout0_36ck1950 FIND v(dout0_36) AT=980.025n

.meas tran vdout0_37ck1950 FIND v(dout0_37) AT=980.025n

.meas tran vdout0_38ck1950 FIND v(dout0_38) AT=980.025n

.meas tran vdout0_39ck1950 FIND v(dout0_39) AT=980.025n

.meas tran vdout0_40ck1950 FIND v(dout0_40) AT=980.025n

.meas tran vdout0_41ck1950 FIND v(dout0_41) AT=980.025n

.meas tran vdout0_42ck1950 FIND v(dout0_42) AT=980.025n

.meas tran vdout0_43ck1950 FIND v(dout0_43) AT=980.025n

.meas tran vdout0_44ck1950 FIND v(dout0_44) AT=980.025n

.meas tran vdout0_45ck1950 FIND v(dout0_45) AT=980.025n

.meas tran vdout0_46ck1950 FIND v(dout0_46) AT=980.025n

.meas tran vdout0_47ck1950 FIND v(dout0_47) AT=980.025n

.meas tran vdout0_48ck1950 FIND v(dout0_48) AT=980.025n

.meas tran vdout0_49ck1950 FIND v(dout0_49) AT=980.025n

.meas tran vdout0_50ck1950 FIND v(dout0_50) AT=980.025n

.meas tran vdout0_51ck1950 FIND v(dout0_51) AT=980.025n

.meas tran vdout0_52ck1950 FIND v(dout0_52) AT=980.025n

.meas tran vdout0_53ck1950 FIND v(dout0_53) AT=980.025n

.meas tran vdout0_54ck1950 FIND v(dout0_54) AT=980.025n

.meas tran vdout0_55ck1950 FIND v(dout0_55) AT=980.025n

.meas tran vdout0_56ck1950 FIND v(dout0_56) AT=980.025n

.meas tran vdout0_57ck1950 FIND v(dout0_57) AT=980.025n

.meas tran vdout0_58ck1950 FIND v(dout0_58) AT=980.025n

.meas tran vdout0_59ck1950 FIND v(dout0_59) AT=980.025n

.meas tran vdout0_60ck1950 FIND v(dout0_60) AT=980.025n

.meas tran vdout0_61ck1950 FIND v(dout0_61) AT=980.025n

.meas tran vdout0_62ck1950 FIND v(dout0_62) AT=980.025n

.meas tran vdout0_63ck1950 FIND v(dout0_63) AT=980.025n

.meas tran vdout0_64ck1950 FIND v(dout0_64) AT=980.025n

.meas tran vdout0_65ck1950 FIND v(dout0_65) AT=980.025n

.meas tran vdout0_66ck1950 FIND v(dout0_66) AT=980.025n

.meas tran vdout0_67ck1950 FIND v(dout0_67) AT=980.025n

.meas tran vdout0_68ck1950 FIND v(dout0_68) AT=980.025n

.meas tran vdout0_69ck1950 FIND v(dout0_69) AT=980.025n

.meas tran vdout0_70ck1950 FIND v(dout0_70) AT=980.025n

.meas tran vdout0_71ck1950 FIND v(dout0_71) AT=980.025n

.meas tran vdout0_72ck1950 FIND v(dout0_72) AT=980.025n

.meas tran vdout0_73ck1950 FIND v(dout0_73) AT=980.025n

.meas tran vdout0_74ck1950 FIND v(dout0_74) AT=980.025n

.meas tran vdout0_75ck1950 FIND v(dout0_75) AT=980.025n

.meas tran vdout0_76ck1950 FIND v(dout0_76) AT=980.025n

.meas tran vdout0_77ck1950 FIND v(dout0_77) AT=980.025n

.meas tran vdout0_78ck1950 FIND v(dout0_78) AT=980.025n

.meas tran vdout0_79ck1950 FIND v(dout0_79) AT=980.025n

.meas tran vdout0_80ck1950 FIND v(dout0_80) AT=980.025n

.meas tran vdout0_81ck1950 FIND v(dout0_81) AT=980.025n

.meas tran vdout0_82ck1950 FIND v(dout0_82) AT=980.025n

.meas tran vdout0_83ck1950 FIND v(dout0_83) AT=980.025n

.meas tran vdout0_84ck1950 FIND v(dout0_84) AT=980.025n

.meas tran vdout0_85ck1950 FIND v(dout0_85) AT=980.025n

.meas tran vdout0_86ck1950 FIND v(dout0_86) AT=980.025n

.meas tran vdout0_87ck1950 FIND v(dout0_87) AT=980.025n

.meas tran vdout0_88ck1950 FIND v(dout0_88) AT=980.025n

.meas tran vdout0_89ck1950 FIND v(dout0_89) AT=980.025n

.meas tran vdout0_90ck1950 FIND v(dout0_90) AT=980.025n

.meas tran vdout0_91ck1950 FIND v(dout0_91) AT=980.025n

.meas tran vdout0_92ck1950 FIND v(dout0_92) AT=980.025n

.meas tran vdout0_93ck1950 FIND v(dout0_93) AT=980.025n

.meas tran vdout0_94ck1950 FIND v(dout0_94) AT=980.025n

.meas tran vdout0_95ck1950 FIND v(dout0_95) AT=980.025n

.meas tran vdout0_96ck1950 FIND v(dout0_96) AT=980.025n

.meas tran vdout0_97ck1950 FIND v(dout0_97) AT=980.025n

.meas tran vdout0_98ck1950 FIND v(dout0_98) AT=980.025n

.meas tran vdout0_99ck1950 FIND v(dout0_99) AT=980.025n

.meas tran vdout0_100ck1950 FIND v(dout0_100) AT=980.025n

.meas tran vdout0_101ck1950 FIND v(dout0_101) AT=980.025n

.meas tran vdout0_102ck1950 FIND v(dout0_102) AT=980.025n

.meas tran vdout0_103ck1950 FIND v(dout0_103) AT=980.025n

.meas tran vdout0_104ck1950 FIND v(dout0_104) AT=980.025n

.meas tran vdout0_105ck1950 FIND v(dout0_105) AT=980.025n

.meas tran vdout0_106ck1950 FIND v(dout0_106) AT=980.025n

.meas tran vdout0_107ck1950 FIND v(dout0_107) AT=980.025n

.meas tran vdout0_108ck1950 FIND v(dout0_108) AT=980.025n

.meas tran vdout0_109ck1950 FIND v(dout0_109) AT=980.025n

.meas tran vdout0_110ck1950 FIND v(dout0_110) AT=980.025n

.meas tran vdout0_111ck1950 FIND v(dout0_111) AT=980.025n

.meas tran vdout0_112ck1950 FIND v(dout0_112) AT=980.025n

.meas tran vdout0_113ck1950 FIND v(dout0_113) AT=980.025n

.meas tran vdout0_114ck1950 FIND v(dout0_114) AT=980.025n

.meas tran vdout0_115ck1950 FIND v(dout0_115) AT=980.025n

.meas tran vdout0_116ck1950 FIND v(dout0_116) AT=980.025n

.meas tran vdout0_117ck1950 FIND v(dout0_117) AT=980.025n

.meas tran vdout0_118ck1950 FIND v(dout0_118) AT=980.025n

.meas tran vdout0_119ck1950 FIND v(dout0_119) AT=980.025n

.meas tran vdout0_120ck1950 FIND v(dout0_120) AT=980.025n

.meas tran vdout0_121ck1950 FIND v(dout0_121) AT=980.025n

.meas tran vdout0_122ck1950 FIND v(dout0_122) AT=980.025n

.meas tran vdout0_123ck1950 FIND v(dout0_123) AT=980.025n

.meas tran vdout0_124ck1950 FIND v(dout0_124) AT=980.025n

.meas tran vdout0_125ck1950 FIND v(dout0_125) AT=980.025n

.meas tran vdout0_126ck1950 FIND v(dout0_126) AT=980.025n

.meas tran vdout0_127ck1950 FIND v(dout0_127) AT=980.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_0ck1980 FIND v(dout0_0) AT=995.025n

.meas tran vdout0_1ck1980 FIND v(dout0_1) AT=995.025n

.meas tran vdout0_2ck1980 FIND v(dout0_2) AT=995.025n

.meas tran vdout0_3ck1980 FIND v(dout0_3) AT=995.025n

.meas tran vdout0_4ck1980 FIND v(dout0_4) AT=995.025n

.meas tran vdout0_5ck1980 FIND v(dout0_5) AT=995.025n

.meas tran vdout0_6ck1980 FIND v(dout0_6) AT=995.025n

.meas tran vdout0_7ck1980 FIND v(dout0_7) AT=995.025n

.meas tran vdout0_8ck1980 FIND v(dout0_8) AT=995.025n

.meas tran vdout0_9ck1980 FIND v(dout0_9) AT=995.025n

.meas tran vdout0_10ck1980 FIND v(dout0_10) AT=995.025n

.meas tran vdout0_11ck1980 FIND v(dout0_11) AT=995.025n

.meas tran vdout0_12ck1980 FIND v(dout0_12) AT=995.025n

.meas tran vdout0_13ck1980 FIND v(dout0_13) AT=995.025n

.meas tran vdout0_14ck1980 FIND v(dout0_14) AT=995.025n

.meas tran vdout0_15ck1980 FIND v(dout0_15) AT=995.025n

.meas tran vdout0_16ck1980 FIND v(dout0_16) AT=995.025n

.meas tran vdout0_17ck1980 FIND v(dout0_17) AT=995.025n

.meas tran vdout0_18ck1980 FIND v(dout0_18) AT=995.025n

.meas tran vdout0_19ck1980 FIND v(dout0_19) AT=995.025n

.meas tran vdout0_20ck1980 FIND v(dout0_20) AT=995.025n

.meas tran vdout0_21ck1980 FIND v(dout0_21) AT=995.025n

.meas tran vdout0_22ck1980 FIND v(dout0_22) AT=995.025n

.meas tran vdout0_23ck1980 FIND v(dout0_23) AT=995.025n

.meas tran vdout0_24ck1980 FIND v(dout0_24) AT=995.025n

.meas tran vdout0_25ck1980 FIND v(dout0_25) AT=995.025n

.meas tran vdout0_26ck1980 FIND v(dout0_26) AT=995.025n

.meas tran vdout0_27ck1980 FIND v(dout0_27) AT=995.025n

.meas tran vdout0_28ck1980 FIND v(dout0_28) AT=995.025n

.meas tran vdout0_29ck1980 FIND v(dout0_29) AT=995.025n

.meas tran vdout0_30ck1980 FIND v(dout0_30) AT=995.025n

.meas tran vdout0_31ck1980 FIND v(dout0_31) AT=995.025n

.meas tran vdout0_32ck1980 FIND v(dout0_32) AT=995.025n

.meas tran vdout0_33ck1980 FIND v(dout0_33) AT=995.025n

.meas tran vdout0_34ck1980 FIND v(dout0_34) AT=995.025n

.meas tran vdout0_35ck1980 FIND v(dout0_35) AT=995.025n

.meas tran vdout0_36ck1980 FIND v(dout0_36) AT=995.025n

.meas tran vdout0_37ck1980 FIND v(dout0_37) AT=995.025n

.meas tran vdout0_38ck1980 FIND v(dout0_38) AT=995.025n

.meas tran vdout0_39ck1980 FIND v(dout0_39) AT=995.025n

.meas tran vdout0_40ck1980 FIND v(dout0_40) AT=995.025n

.meas tran vdout0_41ck1980 FIND v(dout0_41) AT=995.025n

.meas tran vdout0_42ck1980 FIND v(dout0_42) AT=995.025n

.meas tran vdout0_43ck1980 FIND v(dout0_43) AT=995.025n

.meas tran vdout0_44ck1980 FIND v(dout0_44) AT=995.025n

.meas tran vdout0_45ck1980 FIND v(dout0_45) AT=995.025n

.meas tran vdout0_46ck1980 FIND v(dout0_46) AT=995.025n

.meas tran vdout0_47ck1980 FIND v(dout0_47) AT=995.025n

.meas tran vdout0_48ck1980 FIND v(dout0_48) AT=995.025n

.meas tran vdout0_49ck1980 FIND v(dout0_49) AT=995.025n

.meas tran vdout0_50ck1980 FIND v(dout0_50) AT=995.025n

.meas tran vdout0_51ck1980 FIND v(dout0_51) AT=995.025n

.meas tran vdout0_52ck1980 FIND v(dout0_52) AT=995.025n

.meas tran vdout0_53ck1980 FIND v(dout0_53) AT=995.025n

.meas tran vdout0_54ck1980 FIND v(dout0_54) AT=995.025n

.meas tran vdout0_55ck1980 FIND v(dout0_55) AT=995.025n

.meas tran vdout0_56ck1980 FIND v(dout0_56) AT=995.025n

.meas tran vdout0_57ck1980 FIND v(dout0_57) AT=995.025n

.meas tran vdout0_58ck1980 FIND v(dout0_58) AT=995.025n

.meas tran vdout0_59ck1980 FIND v(dout0_59) AT=995.025n

.meas tran vdout0_60ck1980 FIND v(dout0_60) AT=995.025n

.meas tran vdout0_61ck1980 FIND v(dout0_61) AT=995.025n

.meas tran vdout0_62ck1980 FIND v(dout0_62) AT=995.025n

.meas tran vdout0_63ck1980 FIND v(dout0_63) AT=995.025n

.meas tran vdout0_64ck1980 FIND v(dout0_64) AT=995.025n

.meas tran vdout0_65ck1980 FIND v(dout0_65) AT=995.025n

.meas tran vdout0_66ck1980 FIND v(dout0_66) AT=995.025n

.meas tran vdout0_67ck1980 FIND v(dout0_67) AT=995.025n

.meas tran vdout0_68ck1980 FIND v(dout0_68) AT=995.025n

.meas tran vdout0_69ck1980 FIND v(dout0_69) AT=995.025n

.meas tran vdout0_70ck1980 FIND v(dout0_70) AT=995.025n

.meas tran vdout0_71ck1980 FIND v(dout0_71) AT=995.025n

.meas tran vdout0_72ck1980 FIND v(dout0_72) AT=995.025n

.meas tran vdout0_73ck1980 FIND v(dout0_73) AT=995.025n

.meas tran vdout0_74ck1980 FIND v(dout0_74) AT=995.025n

.meas tran vdout0_75ck1980 FIND v(dout0_75) AT=995.025n

.meas tran vdout0_76ck1980 FIND v(dout0_76) AT=995.025n

.meas tran vdout0_77ck1980 FIND v(dout0_77) AT=995.025n

.meas tran vdout0_78ck1980 FIND v(dout0_78) AT=995.025n

.meas tran vdout0_79ck1980 FIND v(dout0_79) AT=995.025n

.meas tran vdout0_80ck1980 FIND v(dout0_80) AT=995.025n

.meas tran vdout0_81ck1980 FIND v(dout0_81) AT=995.025n

.meas tran vdout0_82ck1980 FIND v(dout0_82) AT=995.025n

.meas tran vdout0_83ck1980 FIND v(dout0_83) AT=995.025n

.meas tran vdout0_84ck1980 FIND v(dout0_84) AT=995.025n

.meas tran vdout0_85ck1980 FIND v(dout0_85) AT=995.025n

.meas tran vdout0_86ck1980 FIND v(dout0_86) AT=995.025n

.meas tran vdout0_87ck1980 FIND v(dout0_87) AT=995.025n

.meas tran vdout0_88ck1980 FIND v(dout0_88) AT=995.025n

.meas tran vdout0_89ck1980 FIND v(dout0_89) AT=995.025n

.meas tran vdout0_90ck1980 FIND v(dout0_90) AT=995.025n

.meas tran vdout0_91ck1980 FIND v(dout0_91) AT=995.025n

.meas tran vdout0_92ck1980 FIND v(dout0_92) AT=995.025n

.meas tran vdout0_93ck1980 FIND v(dout0_93) AT=995.025n

.meas tran vdout0_94ck1980 FIND v(dout0_94) AT=995.025n

.meas tran vdout0_95ck1980 FIND v(dout0_95) AT=995.025n

.meas tran vdout0_96ck1980 FIND v(dout0_96) AT=995.025n

.meas tran vdout0_97ck1980 FIND v(dout0_97) AT=995.025n

.meas tran vdout0_98ck1980 FIND v(dout0_98) AT=995.025n

.meas tran vdout0_99ck1980 FIND v(dout0_99) AT=995.025n

.meas tran vdout0_100ck1980 FIND v(dout0_100) AT=995.025n

.meas tran vdout0_101ck1980 FIND v(dout0_101) AT=995.025n

.meas tran vdout0_102ck1980 FIND v(dout0_102) AT=995.025n

.meas tran vdout0_103ck1980 FIND v(dout0_103) AT=995.025n

.meas tran vdout0_104ck1980 FIND v(dout0_104) AT=995.025n

.meas tran vdout0_105ck1980 FIND v(dout0_105) AT=995.025n

.meas tran vdout0_106ck1980 FIND v(dout0_106) AT=995.025n

.meas tran vdout0_107ck1980 FIND v(dout0_107) AT=995.025n

.meas tran vdout0_108ck1980 FIND v(dout0_108) AT=995.025n

.meas tran vdout0_109ck1980 FIND v(dout0_109) AT=995.025n

.meas tran vdout0_110ck1980 FIND v(dout0_110) AT=995.025n

.meas tran vdout0_111ck1980 FIND v(dout0_111) AT=995.025n

.meas tran vdout0_112ck1980 FIND v(dout0_112) AT=995.025n

.meas tran vdout0_113ck1980 FIND v(dout0_113) AT=995.025n

.meas tran vdout0_114ck1980 FIND v(dout0_114) AT=995.025n

.meas tran vdout0_115ck1980 FIND v(dout0_115) AT=995.025n

.meas tran vdout0_116ck1980 FIND v(dout0_116) AT=995.025n

.meas tran vdout0_117ck1980 FIND v(dout0_117) AT=995.025n

.meas tran vdout0_118ck1980 FIND v(dout0_118) AT=995.025n

.meas tran vdout0_119ck1980 FIND v(dout0_119) AT=995.025n

.meas tran vdout0_120ck1980 FIND v(dout0_120) AT=995.025n

.meas tran vdout0_121ck1980 FIND v(dout0_121) AT=995.025n

.meas tran vdout0_122ck1980 FIND v(dout0_122) AT=995.025n

.meas tran vdout0_123ck1980 FIND v(dout0_123) AT=995.025n

.meas tran vdout0_124ck1980 FIND v(dout0_124) AT=995.025n

.meas tran vdout0_125ck1980 FIND v(dout0_125) AT=995.025n

.meas tran vdout0_126ck1980 FIND v(dout0_126) AT=995.025n

.meas tran vdout0_127ck1980 FIND v(dout0_127) AT=995.025n

.meas tran vdout0_0ck1990 FIND v(dout0_0) AT=1000.025n

.meas tran vdout0_1ck1990 FIND v(dout0_1) AT=1000.025n

.meas tran vdout0_2ck1990 FIND v(dout0_2) AT=1000.025n

.meas tran vdout0_3ck1990 FIND v(dout0_3) AT=1000.025n

.meas tran vdout0_4ck1990 FIND v(dout0_4) AT=1000.025n

.meas tran vdout0_5ck1990 FIND v(dout0_5) AT=1000.025n

.meas tran vdout0_6ck1990 FIND v(dout0_6) AT=1000.025n

.meas tran vdout0_7ck1990 FIND v(dout0_7) AT=1000.025n

.meas tran vdout0_8ck1990 FIND v(dout0_8) AT=1000.025n

.meas tran vdout0_9ck1990 FIND v(dout0_9) AT=1000.025n

.meas tran vdout0_10ck1990 FIND v(dout0_10) AT=1000.025n

.meas tran vdout0_11ck1990 FIND v(dout0_11) AT=1000.025n

.meas tran vdout0_12ck1990 FIND v(dout0_12) AT=1000.025n

.meas tran vdout0_13ck1990 FIND v(dout0_13) AT=1000.025n

.meas tran vdout0_14ck1990 FIND v(dout0_14) AT=1000.025n

.meas tran vdout0_15ck1990 FIND v(dout0_15) AT=1000.025n

.meas tran vdout0_16ck1990 FIND v(dout0_16) AT=1000.025n

.meas tran vdout0_17ck1990 FIND v(dout0_17) AT=1000.025n

.meas tran vdout0_18ck1990 FIND v(dout0_18) AT=1000.025n

.meas tran vdout0_19ck1990 FIND v(dout0_19) AT=1000.025n

.meas tran vdout0_20ck1990 FIND v(dout0_20) AT=1000.025n

.meas tran vdout0_21ck1990 FIND v(dout0_21) AT=1000.025n

.meas tran vdout0_22ck1990 FIND v(dout0_22) AT=1000.025n

.meas tran vdout0_23ck1990 FIND v(dout0_23) AT=1000.025n

.meas tran vdout0_24ck1990 FIND v(dout0_24) AT=1000.025n

.meas tran vdout0_25ck1990 FIND v(dout0_25) AT=1000.025n

.meas tran vdout0_26ck1990 FIND v(dout0_26) AT=1000.025n

.meas tran vdout0_27ck1990 FIND v(dout0_27) AT=1000.025n

.meas tran vdout0_28ck1990 FIND v(dout0_28) AT=1000.025n

.meas tran vdout0_29ck1990 FIND v(dout0_29) AT=1000.025n

.meas tran vdout0_30ck1990 FIND v(dout0_30) AT=1000.025n

.meas tran vdout0_31ck1990 FIND v(dout0_31) AT=1000.025n

.meas tran vdout0_32ck1990 FIND v(dout0_32) AT=1000.025n

.meas tran vdout0_33ck1990 FIND v(dout0_33) AT=1000.025n

.meas tran vdout0_34ck1990 FIND v(dout0_34) AT=1000.025n

.meas tran vdout0_35ck1990 FIND v(dout0_35) AT=1000.025n

.meas tran vdout0_36ck1990 FIND v(dout0_36) AT=1000.025n

.meas tran vdout0_37ck1990 FIND v(dout0_37) AT=1000.025n

.meas tran vdout0_38ck1990 FIND v(dout0_38) AT=1000.025n

.meas tran vdout0_39ck1990 FIND v(dout0_39) AT=1000.025n

.meas tran vdout0_40ck1990 FIND v(dout0_40) AT=1000.025n

.meas tran vdout0_41ck1990 FIND v(dout0_41) AT=1000.025n

.meas tran vdout0_42ck1990 FIND v(dout0_42) AT=1000.025n

.meas tran vdout0_43ck1990 FIND v(dout0_43) AT=1000.025n

.meas tran vdout0_44ck1990 FIND v(dout0_44) AT=1000.025n

.meas tran vdout0_45ck1990 FIND v(dout0_45) AT=1000.025n

.meas tran vdout0_46ck1990 FIND v(dout0_46) AT=1000.025n

.meas tran vdout0_47ck1990 FIND v(dout0_47) AT=1000.025n

.meas tran vdout0_48ck1990 FIND v(dout0_48) AT=1000.025n

.meas tran vdout0_49ck1990 FIND v(dout0_49) AT=1000.025n

.meas tran vdout0_50ck1990 FIND v(dout0_50) AT=1000.025n

.meas tran vdout0_51ck1990 FIND v(dout0_51) AT=1000.025n

.meas tran vdout0_52ck1990 FIND v(dout0_52) AT=1000.025n

.meas tran vdout0_53ck1990 FIND v(dout0_53) AT=1000.025n

.meas tran vdout0_54ck1990 FIND v(dout0_54) AT=1000.025n

.meas tran vdout0_55ck1990 FIND v(dout0_55) AT=1000.025n

.meas tran vdout0_56ck1990 FIND v(dout0_56) AT=1000.025n

.meas tran vdout0_57ck1990 FIND v(dout0_57) AT=1000.025n

.meas tran vdout0_58ck1990 FIND v(dout0_58) AT=1000.025n

.meas tran vdout0_59ck1990 FIND v(dout0_59) AT=1000.025n

.meas tran vdout0_60ck1990 FIND v(dout0_60) AT=1000.025n

.meas tran vdout0_61ck1990 FIND v(dout0_61) AT=1000.025n

.meas tran vdout0_62ck1990 FIND v(dout0_62) AT=1000.025n

.meas tran vdout0_63ck1990 FIND v(dout0_63) AT=1000.025n

.meas tran vdout0_64ck1990 FIND v(dout0_64) AT=1000.025n

.meas tran vdout0_65ck1990 FIND v(dout0_65) AT=1000.025n

.meas tran vdout0_66ck1990 FIND v(dout0_66) AT=1000.025n

.meas tran vdout0_67ck1990 FIND v(dout0_67) AT=1000.025n

.meas tran vdout0_68ck1990 FIND v(dout0_68) AT=1000.025n

.meas tran vdout0_69ck1990 FIND v(dout0_69) AT=1000.025n

.meas tran vdout0_70ck1990 FIND v(dout0_70) AT=1000.025n

.meas tran vdout0_71ck1990 FIND v(dout0_71) AT=1000.025n

.meas tran vdout0_72ck1990 FIND v(dout0_72) AT=1000.025n

.meas tran vdout0_73ck1990 FIND v(dout0_73) AT=1000.025n

.meas tran vdout0_74ck1990 FIND v(dout0_74) AT=1000.025n

.meas tran vdout0_75ck1990 FIND v(dout0_75) AT=1000.025n

.meas tran vdout0_76ck1990 FIND v(dout0_76) AT=1000.025n

.meas tran vdout0_77ck1990 FIND v(dout0_77) AT=1000.025n

.meas tran vdout0_78ck1990 FIND v(dout0_78) AT=1000.025n

.meas tran vdout0_79ck1990 FIND v(dout0_79) AT=1000.025n

.meas tran vdout0_80ck1990 FIND v(dout0_80) AT=1000.025n

.meas tran vdout0_81ck1990 FIND v(dout0_81) AT=1000.025n

.meas tran vdout0_82ck1990 FIND v(dout0_82) AT=1000.025n

.meas tran vdout0_83ck1990 FIND v(dout0_83) AT=1000.025n

.meas tran vdout0_84ck1990 FIND v(dout0_84) AT=1000.025n

.meas tran vdout0_85ck1990 FIND v(dout0_85) AT=1000.025n

.meas tran vdout0_86ck1990 FIND v(dout0_86) AT=1000.025n

.meas tran vdout0_87ck1990 FIND v(dout0_87) AT=1000.025n

.meas tran vdout0_88ck1990 FIND v(dout0_88) AT=1000.025n

.meas tran vdout0_89ck1990 FIND v(dout0_89) AT=1000.025n

.meas tran vdout0_90ck1990 FIND v(dout0_90) AT=1000.025n

.meas tran vdout0_91ck1990 FIND v(dout0_91) AT=1000.025n

.meas tran vdout0_92ck1990 FIND v(dout0_92) AT=1000.025n

.meas tran vdout0_93ck1990 FIND v(dout0_93) AT=1000.025n

.meas tran vdout0_94ck1990 FIND v(dout0_94) AT=1000.025n

.meas tran vdout0_95ck1990 FIND v(dout0_95) AT=1000.025n

.meas tran vdout0_96ck1990 FIND v(dout0_96) AT=1000.025n

.meas tran vdout0_97ck1990 FIND v(dout0_97) AT=1000.025n

.meas tran vdout0_98ck1990 FIND v(dout0_98) AT=1000.025n

.meas tran vdout0_99ck1990 FIND v(dout0_99) AT=1000.025n

.meas tran vdout0_100ck1990 FIND v(dout0_100) AT=1000.025n

.meas tran vdout0_101ck1990 FIND v(dout0_101) AT=1000.025n

.meas tran vdout0_102ck1990 FIND v(dout0_102) AT=1000.025n

.meas tran vdout0_103ck1990 FIND v(dout0_103) AT=1000.025n

.meas tran vdout0_104ck1990 FIND v(dout0_104) AT=1000.025n

.meas tran vdout0_105ck1990 FIND v(dout0_105) AT=1000.025n

.meas tran vdout0_106ck1990 FIND v(dout0_106) AT=1000.025n

.meas tran vdout0_107ck1990 FIND v(dout0_107) AT=1000.025n

.meas tran vdout0_108ck1990 FIND v(dout0_108) AT=1000.025n

.meas tran vdout0_109ck1990 FIND v(dout0_109) AT=1000.025n

.meas tran vdout0_110ck1990 FIND v(dout0_110) AT=1000.025n

.meas tran vdout0_111ck1990 FIND v(dout0_111) AT=1000.025n

.meas tran vdout0_112ck1990 FIND v(dout0_112) AT=1000.025n

.meas tran vdout0_113ck1990 FIND v(dout0_113) AT=1000.025n

.meas tran vdout0_114ck1990 FIND v(dout0_114) AT=1000.025n

.meas tran vdout0_115ck1990 FIND v(dout0_115) AT=1000.025n

.meas tran vdout0_116ck1990 FIND v(dout0_116) AT=1000.025n

.meas tran vdout0_117ck1990 FIND v(dout0_117) AT=1000.025n

.meas tran vdout0_118ck1990 FIND v(dout0_118) AT=1000.025n

.meas tran vdout0_119ck1990 FIND v(dout0_119) AT=1000.025n

.meas tran vdout0_120ck1990 FIND v(dout0_120) AT=1000.025n

.meas tran vdout0_121ck1990 FIND v(dout0_121) AT=1000.025n

.meas tran vdout0_122ck1990 FIND v(dout0_122) AT=1000.025n

.meas tran vdout0_123ck1990 FIND v(dout0_123) AT=1000.025n

.meas tran vdout0_124ck1990 FIND v(dout0_124) AT=1000.025n

.meas tran vdout0_125ck1990 FIND v(dout0_125) AT=1000.025n

.meas tran vdout0_126ck1990 FIND v(dout0_126) AT=1000.025n

.meas tran vdout0_127ck1990 FIND v(dout0_127) AT=1000.025n

.meas tran vdout0_0ck2020 FIND v(dout0_0) AT=1015.025n

.meas tran vdout0_1ck2020 FIND v(dout0_1) AT=1015.025n

.meas tran vdout0_2ck2020 FIND v(dout0_2) AT=1015.025n

.meas tran vdout0_3ck2020 FIND v(dout0_3) AT=1015.025n

.meas tran vdout0_4ck2020 FIND v(dout0_4) AT=1015.025n

.meas tran vdout0_5ck2020 FIND v(dout0_5) AT=1015.025n

.meas tran vdout0_6ck2020 FIND v(dout0_6) AT=1015.025n

.meas tran vdout0_7ck2020 FIND v(dout0_7) AT=1015.025n

.meas tran vdout0_8ck2020 FIND v(dout0_8) AT=1015.025n

.meas tran vdout0_9ck2020 FIND v(dout0_9) AT=1015.025n

.meas tran vdout0_10ck2020 FIND v(dout0_10) AT=1015.025n

.meas tran vdout0_11ck2020 FIND v(dout0_11) AT=1015.025n

.meas tran vdout0_12ck2020 FIND v(dout0_12) AT=1015.025n

.meas tran vdout0_13ck2020 FIND v(dout0_13) AT=1015.025n

.meas tran vdout0_14ck2020 FIND v(dout0_14) AT=1015.025n

.meas tran vdout0_15ck2020 FIND v(dout0_15) AT=1015.025n

.meas tran vdout0_16ck2020 FIND v(dout0_16) AT=1015.025n

.meas tran vdout0_17ck2020 FIND v(dout0_17) AT=1015.025n

.meas tran vdout0_18ck2020 FIND v(dout0_18) AT=1015.025n

.meas tran vdout0_19ck2020 FIND v(dout0_19) AT=1015.025n

.meas tran vdout0_20ck2020 FIND v(dout0_20) AT=1015.025n

.meas tran vdout0_21ck2020 FIND v(dout0_21) AT=1015.025n

.meas tran vdout0_22ck2020 FIND v(dout0_22) AT=1015.025n

.meas tran vdout0_23ck2020 FIND v(dout0_23) AT=1015.025n

.meas tran vdout0_24ck2020 FIND v(dout0_24) AT=1015.025n

.meas tran vdout0_25ck2020 FIND v(dout0_25) AT=1015.025n

.meas tran vdout0_26ck2020 FIND v(dout0_26) AT=1015.025n

.meas tran vdout0_27ck2020 FIND v(dout0_27) AT=1015.025n

.meas tran vdout0_28ck2020 FIND v(dout0_28) AT=1015.025n

.meas tran vdout0_29ck2020 FIND v(dout0_29) AT=1015.025n

.meas tran vdout0_30ck2020 FIND v(dout0_30) AT=1015.025n

.meas tran vdout0_31ck2020 FIND v(dout0_31) AT=1015.025n

.meas tran vdout0_32ck2020 FIND v(dout0_32) AT=1015.025n

.meas tran vdout0_33ck2020 FIND v(dout0_33) AT=1015.025n

.meas tran vdout0_34ck2020 FIND v(dout0_34) AT=1015.025n

.meas tran vdout0_35ck2020 FIND v(dout0_35) AT=1015.025n

.meas tran vdout0_36ck2020 FIND v(dout0_36) AT=1015.025n

.meas tran vdout0_37ck2020 FIND v(dout0_37) AT=1015.025n

.meas tran vdout0_38ck2020 FIND v(dout0_38) AT=1015.025n

.meas tran vdout0_39ck2020 FIND v(dout0_39) AT=1015.025n

.meas tran vdout0_40ck2020 FIND v(dout0_40) AT=1015.025n

.meas tran vdout0_41ck2020 FIND v(dout0_41) AT=1015.025n

.meas tran vdout0_42ck2020 FIND v(dout0_42) AT=1015.025n

.meas tran vdout0_43ck2020 FIND v(dout0_43) AT=1015.025n

.meas tran vdout0_44ck2020 FIND v(dout0_44) AT=1015.025n

.meas tran vdout0_45ck2020 FIND v(dout0_45) AT=1015.025n

.meas tran vdout0_46ck2020 FIND v(dout0_46) AT=1015.025n

.meas tran vdout0_47ck2020 FIND v(dout0_47) AT=1015.025n

.meas tran vdout0_48ck2020 FIND v(dout0_48) AT=1015.025n

.meas tran vdout0_49ck2020 FIND v(dout0_49) AT=1015.025n

.meas tran vdout0_50ck2020 FIND v(dout0_50) AT=1015.025n

.meas tran vdout0_51ck2020 FIND v(dout0_51) AT=1015.025n

.meas tran vdout0_52ck2020 FIND v(dout0_52) AT=1015.025n

.meas tran vdout0_53ck2020 FIND v(dout0_53) AT=1015.025n

.meas tran vdout0_54ck2020 FIND v(dout0_54) AT=1015.025n

.meas tran vdout0_55ck2020 FIND v(dout0_55) AT=1015.025n

.meas tran vdout0_56ck2020 FIND v(dout0_56) AT=1015.025n

.meas tran vdout0_57ck2020 FIND v(dout0_57) AT=1015.025n

.meas tran vdout0_58ck2020 FIND v(dout0_58) AT=1015.025n

.meas tran vdout0_59ck2020 FIND v(dout0_59) AT=1015.025n

.meas tran vdout0_60ck2020 FIND v(dout0_60) AT=1015.025n

.meas tran vdout0_61ck2020 FIND v(dout0_61) AT=1015.025n

.meas tran vdout0_62ck2020 FIND v(dout0_62) AT=1015.025n

.meas tran vdout0_63ck2020 FIND v(dout0_63) AT=1015.025n

.meas tran vdout0_64ck2020 FIND v(dout0_64) AT=1015.025n

.meas tran vdout0_65ck2020 FIND v(dout0_65) AT=1015.025n

.meas tran vdout0_66ck2020 FIND v(dout0_66) AT=1015.025n

.meas tran vdout0_67ck2020 FIND v(dout0_67) AT=1015.025n

.meas tran vdout0_68ck2020 FIND v(dout0_68) AT=1015.025n

.meas tran vdout0_69ck2020 FIND v(dout0_69) AT=1015.025n

.meas tran vdout0_70ck2020 FIND v(dout0_70) AT=1015.025n

.meas tran vdout0_71ck2020 FIND v(dout0_71) AT=1015.025n

.meas tran vdout0_72ck2020 FIND v(dout0_72) AT=1015.025n

.meas tran vdout0_73ck2020 FIND v(dout0_73) AT=1015.025n

.meas tran vdout0_74ck2020 FIND v(dout0_74) AT=1015.025n

.meas tran vdout0_75ck2020 FIND v(dout0_75) AT=1015.025n

.meas tran vdout0_76ck2020 FIND v(dout0_76) AT=1015.025n

.meas tran vdout0_77ck2020 FIND v(dout0_77) AT=1015.025n

.meas tran vdout0_78ck2020 FIND v(dout0_78) AT=1015.025n

.meas tran vdout0_79ck2020 FIND v(dout0_79) AT=1015.025n

.meas tran vdout0_80ck2020 FIND v(dout0_80) AT=1015.025n

.meas tran vdout0_81ck2020 FIND v(dout0_81) AT=1015.025n

.meas tran vdout0_82ck2020 FIND v(dout0_82) AT=1015.025n

.meas tran vdout0_83ck2020 FIND v(dout0_83) AT=1015.025n

.meas tran vdout0_84ck2020 FIND v(dout0_84) AT=1015.025n

.meas tran vdout0_85ck2020 FIND v(dout0_85) AT=1015.025n

.meas tran vdout0_86ck2020 FIND v(dout0_86) AT=1015.025n

.meas tran vdout0_87ck2020 FIND v(dout0_87) AT=1015.025n

.meas tran vdout0_88ck2020 FIND v(dout0_88) AT=1015.025n

.meas tran vdout0_89ck2020 FIND v(dout0_89) AT=1015.025n

.meas tran vdout0_90ck2020 FIND v(dout0_90) AT=1015.025n

.meas tran vdout0_91ck2020 FIND v(dout0_91) AT=1015.025n

.meas tran vdout0_92ck2020 FIND v(dout0_92) AT=1015.025n

.meas tran vdout0_93ck2020 FIND v(dout0_93) AT=1015.025n

.meas tran vdout0_94ck2020 FIND v(dout0_94) AT=1015.025n

.meas tran vdout0_95ck2020 FIND v(dout0_95) AT=1015.025n

.meas tran vdout0_96ck2020 FIND v(dout0_96) AT=1015.025n

.meas tran vdout0_97ck2020 FIND v(dout0_97) AT=1015.025n

.meas tran vdout0_98ck2020 FIND v(dout0_98) AT=1015.025n

.meas tran vdout0_99ck2020 FIND v(dout0_99) AT=1015.025n

.meas tran vdout0_100ck2020 FIND v(dout0_100) AT=1015.025n

.meas tran vdout0_101ck2020 FIND v(dout0_101) AT=1015.025n

.meas tran vdout0_102ck2020 FIND v(dout0_102) AT=1015.025n

.meas tran vdout0_103ck2020 FIND v(dout0_103) AT=1015.025n

.meas tran vdout0_104ck2020 FIND v(dout0_104) AT=1015.025n

.meas tran vdout0_105ck2020 FIND v(dout0_105) AT=1015.025n

.meas tran vdout0_106ck2020 FIND v(dout0_106) AT=1015.025n

.meas tran vdout0_107ck2020 FIND v(dout0_107) AT=1015.025n

.meas tran vdout0_108ck2020 FIND v(dout0_108) AT=1015.025n

.meas tran vdout0_109ck2020 FIND v(dout0_109) AT=1015.025n

.meas tran vdout0_110ck2020 FIND v(dout0_110) AT=1015.025n

.meas tran vdout0_111ck2020 FIND v(dout0_111) AT=1015.025n

.meas tran vdout0_112ck2020 FIND v(dout0_112) AT=1015.025n

.meas tran vdout0_113ck2020 FIND v(dout0_113) AT=1015.025n

.meas tran vdout0_114ck2020 FIND v(dout0_114) AT=1015.025n

.meas tran vdout0_115ck2020 FIND v(dout0_115) AT=1015.025n

.meas tran vdout0_116ck2020 FIND v(dout0_116) AT=1015.025n

.meas tran vdout0_117ck2020 FIND v(dout0_117) AT=1015.025n

.meas tran vdout0_118ck2020 FIND v(dout0_118) AT=1015.025n

.meas tran vdout0_119ck2020 FIND v(dout0_119) AT=1015.025n

.meas tran vdout0_120ck2020 FIND v(dout0_120) AT=1015.025n

.meas tran vdout0_121ck2020 FIND v(dout0_121) AT=1015.025n

.meas tran vdout0_122ck2020 FIND v(dout0_122) AT=1015.025n

.meas tran vdout0_123ck2020 FIND v(dout0_123) AT=1015.025n

.meas tran vdout0_124ck2020 FIND v(dout0_124) AT=1015.025n

.meas tran vdout0_125ck2020 FIND v(dout0_125) AT=1015.025n

.meas tran vdout0_126ck2020 FIND v(dout0_126) AT=1015.025n

.meas tran vdout0_127ck2020 FIND v(dout0_127) AT=1015.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n
